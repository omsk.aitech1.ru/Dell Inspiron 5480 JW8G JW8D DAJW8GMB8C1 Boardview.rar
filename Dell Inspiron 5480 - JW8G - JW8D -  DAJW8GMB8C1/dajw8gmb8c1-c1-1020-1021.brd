# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DQ1: length 37.4
  TOP w0.127: VRAM2.C3 219.52,75.21 v2(219.9,75.6)
  IN1 w0.102: 219.24,72.19 219.39,72.34 219.39,75.09 v2(219.9,75.6)
  IN1 w0.114: v2(197.12,86.82) 196.32,86.03 196.32,84.87 196.71,84.49 196.71,83.32 197.13,82.9 197.46,82.9 199.14,81.22 199.62,81.22 210.36,70.47 217.52,70.47 219.24,72.19
  BOTTOM w0.127: U13.F18 196.72,87.22 v2(197.12,86.82)
VMA_DQ2: length 36.5
  TOP w0.127: VRAM2.A2 220.32,73.1 v2(220.28,73.06)
  IN1 w0.102: v2(195.49,85.99) 195.9,85.58 195.9,84.66 196.28,84.28 196.28,82.45
  IN1 w0.114: 196.28,82.45 196.28,82.37 198.38,80.28 199.37,80.28 210.07,69.58 217.89,69.58 220.23,71.92 220.23,73.01 v2(220.28,73.06)
  BOTTOM w0.127: v2(195.49,85.99) 195.08,86.4 U13.E16
VMA_DQ3: length 38.1
  TOP w0.102: VRAM2.C2 v2(220.73,74.8)
  IN1 w0.102: 219.76,72.12 219.82,72.18 219.82,73.33 220.33,73.83 220.33,74.4 v2(220.73,74.8)
  IN1 w0.114: 219.76,72.12 217.68,70.04 210.2,70.04 199.55,80.69 198.85,80.69 197.93,81.62 197.93,82.05 197.29,82.69 196.75,82.69 196.49,82.94 196.49,84.4 196.11,84.78 196.11,86.64 v2(196.3,86.83)
  BOTTOM w0.127: v2(196.3,86.83) 195.89,87.24 U13.F17
VMA_DQ4: length 34.1
  TOP w0.127: VRAM2.A7 216.32,73.62 v2(215.93,74)
  IN1 w0.102: 214.74,72.83 214.84,72.73 215.25,72.73 215.5,72.99 215.5,73.43 215.93,73.87 v2(215.93,74)
  IN1 w0.114: v2(198.76,85.18) 198.76,85.06 200.49,83.32 200.92,83.32 203.16,81.08 203.32,81.08 203.77,81.53 203.93,81.53 204.09,81.37 204.09,81.21 203.65,80.76 203.65,80.6 203.81,80.44 203.97,80.44 205.02,81.49 205.2,81.49 205.34,81.34 205.34,81.16 204.29,80.11 204.29,79.95 204.46,79.79 204.62,79.79 205.7,80.88 205.88,80.88 206.03,80.73 206.03,80.55 204.94,79.47 204.94,79.31 205.1,79.14 205.26,79.14 205.71,79.59 205.87,79.59 206.03,79.43 206.03,79.27 205.59,78.82 205.59,78.66 205.81,78.43 205.97,78.43 206.39,78.85 206.56,78.85 212.58,72.83 214.74,72.83
  BOTTOM w0.127: U13.D20 198.36,85.58 v2(198.76,85.18)
VMA_DQ5: length 32
  TOP w0.102: v2(216.85,76.67) 216.32,76.14 VRAM2.D7
  IN1 w0.102: v2(216.85,76.67) 216.64,76.67 216.39,76.41 216.39,74.71 216.09,74.41 214.82,74.41 214.59,74.18
  IN1 w0.114: 214.59,74.18 214.59,73.9 214.36,73.67 212.41,73.67 208.11,77.97 208.11,78.13 208.59,78.62 208.59,78.78 208.43,78.94 208.27,78.94 207.79,78.46 207.63,78.46 207.46,78.62 207.46,78.78 207.95,79.26 207.95,79.42 207.78,79.59 207.62,79.59 207.14,79.1 206.98,79.1 206.82,79.27 206.82,79.43 207.3,79.91 207.3,80.07 207.14,80.23 206.98,80.23 206.49,79.75 206.33,79.75 206.21,79.88 206.21,80.12 206.61,80.53 206.61,80.76 205.42,81.95 202.98,81.95 201.3,83.63 200.57,83.63 199.6,84.6 v2(199.6,85.18)
  BOTTOM w0.127: v2(199.6,85.18) 199.2,85.58 U13.D21
VMA_DQ6: length 34.9
  TOP w0.127: VRAM2.C8 215.49,75.21 v2(215.1,75.6)
  IN1 w0.102: v2(198.76,86.82) 199.02,86.82 199.43,86.41 199.76,86.41 200.02,86.15 200.02,85.88 200.26,85.64 201.36,85.64 201.65,85.35 201.65,84.27 201.93,84 202.38,84
  IN1 w0.114: 202.38,84 202.7,84 202.83,84.12 202.83,84.64 202.93,84.75 203.18,84.75 203.31,84.62 203.31,83.07 203.5,82.88 205.25,82.88 205.39,83.01 206.39,83.01 207.79,81.61 207.95,81.61 208.5,82.17 208.68,82.17 208.83,82.02 208.83,81.84 208.27,81.29 208.27,81.13 208.44,80.97 208.6,80.97 209.2,81.57 209.38,81.57 209.53,81.43 209.53,81.25 208.92,80.64 208.92,80.48 209.08,80.32 209.24,80.32 209.46,80.54 209.63,80.54 209.79,80.38 209.79,80.21 209.57,80 209.57,79.83 210.88,78.52 210.88,78.29 210.03,77.44 210.03,77.24 210.76,76.51 211.45,76.51 211.56,76.62 211.56,77.79 211.69,77.91 211.89,77.91 212.02,77.79 212.02,76.62 212.13,76.51 213.07,76.51 213.29,76.29 213.29,75.22 213.42,75.09 214.6,75.09 v2(215.1,75.6)
  BOTTOM w0.127: U13.F20 198.36,87.22 v2(198.76,86.82)
VMA_DQ7: length 34.3
  TOP w0.127: v2(215.12,74.81) 215.51,74.42 VRAM2.B8
  IN1 w0.102: 201.66,83.91 200.74,84.82 200.27,84.82 200.03,85.06 200.03,85.54 v2(199.6,85.98)
  IN1 w0.114: 201.66,83.91 203.11,82.46 205.54,82.46 205.72,82.28 205.88,82.28 206.12,82.51 206.28,82.51 206.44,82.35 206.44,82.19 206.2,81.95 206.2,81.79 206.37,81.63 206.53,81.63 206.76,81.87 206.93,81.87 207.09,81.71 207.09,81.54 206.85,81.31 206.85,81.15 207.01,80.98 207.17,80.98 207.41,81.22 207.57,81.22 207.73,81.06 207.73,80.9 207.5,80.66 207.5,80.5 207.66,80.34 207.82,80.34 208.06,80.57 208.22,80.57 208.38,80.41 208.38,80.25 208.14,80.01 208.14,79.85 208.31,79.69 208.47,79.69 208.7,79.93 208.87,79.93 209.03,79.77 209.03,79.6 208.79,79.37 208.79,79.21 208.96,79.04 209.12,79.04 209.36,79.27 209.52,79.27 209.68,79.11 209.68,78.95 209.45,78.71 209.45,78.53 209.57,78.41 209.75,78.41 209.98,78.64 210.16,78.64 210.3,78.49 210.3,78.31 209.41,77.42 209.41,77.26 210.95,75.72 211.11,75.72 211.48,76.09 211.66,76.09 211.81,75.95 211.81,75.77 211.44,75.4 211.44,75.24 211.6,75.08 211.76,75.08 212.55,75.86 212.73,75.86 212.87,75.72 212.87,75.54 212.08,74.75 212.08,74.59 212.34,74.33 212.57,74.33 212.69,74.45 212.69,74.74 212.82,74.87 213.02,74.87 213.15,74.74 213.15,74.23 213.27,74.1 213.48,74.1 213.6,74.23 213.6,74.56 213.72,74.67 214.77,74.67 214.92,74.83 215.11,74.83 v2(215.12,74.81)
  BOTTOM w0.127: v2(199.6,85.98) 199.2,86.38 U13.E21
VMA_DQ8: length 40.2
  TOP w0.102: v2(193.79,86.79) 194.15,86.42 194.8,86.42 195.05,86.17 195.05,85.83 195.32,85.56 195.74,85.56 196.21,85.09 196.21,84.68 196.91,83.98 197.29,83.98 197.47,83.8 198.31,83.8
  TOP w0.127: 198.31,83.8 199.17,83.8 200.21,82.76 204.96,82.76 205.43,82.3 206.68,82.3 207.2,81.77 207.38,81.77 207.82,82.21 208,82.21 208.18,82.03 208.18,81.85 207.74,81.41 207.74,81.23 207.92,81.05 208.1,81.05 208.54,81.49 208.72,81.49 208.9,81.32 208.9,81.14 208.46,80.7 208.46,80.52 208.64,80.34 208.82,80.34 209.26,80.78 209.44,80.78 209.62,80.6 209.62,80.42 209.18,79.98 209.18,79.8 209.54,79.44 v1(209.84,79.44) 209.96,79.44 210.09,79.56 210.09,80.5 210.22,80.63 210.5,80.63 210.63,80.5 210.63,79.59 210.75,79.46 211.01,79.46 211.08,79.54 211.08,80.28 211.26,80.45 211.44,80.45 211.92,79.97 211.92,78.76 212,78.68 212.17,78.68 212.35,78.85 212.35,80.1 212.45,80.2 212.76,80.2 212.91,80.05 212.91,78.45 212.78,78.32 212.58,78.32 212.45,78.19 212.45,77.89 212.56,77.79 213.47,77.79 213.6,77.66 213.6,77.02 213.72,76.9 214,76.9 214.13,77.02 214.13,77.1 214.26,77.22 215.42,77.22 215.51,77.32 VRAM2.F8
  BOTTOM w0.127: U13.E15 194.17,86.4 v2(193.79,86.79)
VMA_DQ9: length 39.7
  TOP w0.102: 197.72,83.25 197.59,83.12 196.93,83.12 196.68,83.37 196.68,83.92 195.99,84.61 195.99,84.61 v2(195.45,85.16) ; VRAM2.F7 216.51,77.62 217.25,76.87 217.25,73.67 216.19,72.6 214.46,72.6 213.67,73.39
  TOP w0.127: 213.67,73.39 213.67,74.43 213.44,74.67 213.44,74.85 213.78,75.19 213.78,75.37 213.6,75.55 213.42,75.55 213.08,75.2 212.9,75.2 212.72,75.38 212.72,75.56 213.43,76.27 213.43,76.45 213.25,76.63 213.07,76.63 212.36,75.92 212.18,75.92 212.02,76.08 212.02,76.29 212.4,76.67 212.4,76.9 212.02,77.28 212.02,77.96 211.43,78.56 209.8,78.56 208.77,79.59 208.03,79.59 207.86,79.77 207.86,80.4 207.63,80.63 207.32,80.63 207.17,80.78 207.17,81.19 206.92,81.44 v1(206.18,81.44) 205.67,81.44 204.76,82.36 200.01,82.36 199.12,83.25 197.72,83.25
  BOTTOM w0.127: U13.D15 194.61,85.23 195.38,85.23 v2(195.45,85.16)
VMA_DQ10: length 41.4
  TOP w0.102: v2(194.67,86.83) 194.7,86.8 194.83,86.8 195.21,86.42 196.35,86.42 196.55,86.22 196.55,84.92 196.68,84.8 197.24,84.8
  TOP w0.127: VRAM2.H8 215.13,78.83 214.31,78.83 214.13,78.65 213.83,78.65 213.65,78.47 213.47,78.47 213.34,78.6 213.34,80.28 212.99,80.63 211.89,80.63 211.43,81.09 209.78,81.09 209.33,81.54 209.33,85.84 209.2,85.97 209,85.97 208.87,85.84 208.87,84.44 208.75,84.31 208.49,84.31 208.39,84.42 208.39,85.25 208.26,85.38 208.06,85.38 207.93,85.25 207.93,83.45 208.06,83.32 208.75,83.32 208.87,83.2 208.87,82.36 208.77,82.26 208.57,82.26 208.1,82.73 v1(207.65,82.73) 205.61,82.73 204.96,83.37 204.96,83.78 204.5,84.24 203.41,84.24 203.28,84.11 203.28,83.25 203.16,83.12 200.41,83.12 199.17,84.36 198.36,84.36 198.23,84.49 198.23,85.43 198.1,85.56 197.8,85.56 197.67,85.43 197.67,84.92 197.54,84.8 197.24,84.8
  BOTTOM w0.127: U13.F15 194.24,87.21 194.67,86.77 v2(194.67,86.83)
VMA_DQ11: length 42.4
  TOP w0.102: 199.19,84.95 199.19,86.15 198.92,86.41 196.95,86.41 196.72,86.64 196.71,86.66 196.71,87 196.47,87.24 193.66,87.24 193.24,86.82 v2(192.96,86.82)
  TOP w0.127: VRAM2.H7 216.42,79.32 216.42,79.49 216.29,79.62 214.44,79.62 214.28,79.77 214.28,80.45 213.67,81.06 212.09,81.06 212.07,81.08 211.63,81.52 209.96,81.52 209.76,81.72 209.76,86.57 209.64,86.7 v1(209,86.7) 208.57,86.7 208.44,86.57 208.44,85.94 208.31,85.81 208.11,85.81 207.98,85.94 207.98,86.5 207.86,86.63 207.62,86.63 207.5,86.5 207.5,83.41 207.25,83.16 205.79,83.16 205.62,83.32 205.62,83.7 205.14,84.19 205.14,84.57 205.06,84.64 203.11,84.64 202.98,84.77 202.7,84.77 202.57,84.64 202.57,84.36 202.88,84.06 202.88,83.6 202.75,83.48 202.01,83.48 201.6,83.89 201.6,84.52 201.47,84.64 201.22,84.64 201.09,84.52 201.09,83.6 200.96,83.48 200.67,83.48 199.19,84.95
  BOTTOM w0.127: U13.F13 192.56,87.22 v2(192.96,86.82)
VMA_DQ12: length 43.8
  TOP w0.102: v2(192.16,84.39) 192.16,83.73 192.57,83.32 192.57,82.79
  TOP w0.127: 192.57,82.79 195.33,80.02 202.29,80.02 v1(210.46,71.86) 212.07,70.24 218.42,70.24 221.95,73.77 221.95,76.46 221.26,77.16 221.09,77.16 220.73,77.51 220.73,78 VRAM2.G2
  BOTTOM w0.127: U13.C13 192.56,84.79 v2(192.16,84.39)
VMA_DQ13: length 40.6
  TOP w0.102: 218.5,72.56 218.58,72.64 218.58,76.71 218.81,76.94 219.39,76.94 VRAM2.E3
  TOP w0.127: 218.5,72.56 218.5,72.12 218.58,72.05 219.08,72.05 219.21,71.92 219.21,71.69 219.08,71.56 218.45,71.56 218.32,71.44 218.32,70.8 218.19,70.67 212.38,70.67 v1(209.44,73.61) 209.32,73.61 202.6,80.32 195.57,80.32 194.75,81.14 194.75,82.66 194.41,83 193.67,83 v2(193.2,83.48)
  BOTTOM w0.127: U13.B13 192.68,84 v2(193.2,83.48)
VMA_DQ14: length 42.1
  TOP w0.102: v2(192.17,85.99) 192.43,85.99 192.83,85.59 193.59,85.59 193.63,85.63 194.08,85.63 194.84,84.87 194.84,84.15 195.21,83.79 195.75,83.79 195.79,83.83 196.12,83.83 196.25,83.7 196.25,82.87 196.43,82.69 196.76,82.69 ; VRAM2.H3 219.51,79.16 217.66,77.31 217.66,73.27 216.51,72.12 216.34,72.12
  TOP w0.127: 216.34,72.12 213.95,72.12 212.49,73.58 212.49,73.76 212.68,73.95 212.68,74.13 212.5,74.31 212.32,74.31 212.13,74.12 211.95,74.12 211.78,74.3 211.78,74.48 211.96,74.67 211.96,74.85 211.78,75.03 211.6,75.03 211.42,74.84 211.24,74.84 v1(210.56,75.51) 209.86,76.21 209.86,76.85 209.66,77.05 209.66,77.48 208.72,78.42 207.27,78.42 204.12,81.57 198.59,81.57 197.47,82.69 196.76,82.69
  BOTTOM w0.127: v2(192.17,85.99) 192.56,86.38 U13.E13
VMA_DQ15: length 41.1
  TOP w0.102: VRAM2.F2 219.85,77.15 218.72,77.15 218.37,76.79 218.37,72.76 218.27,72.66 ; v2(192.96,85.18) 193.02,85.18 193.4,84.8 193.4,84.24 193.61,84.03 194.07,84.03 194.6,83.51 194.6,83.25
  TOP w0.127: 218.27,72.66 217.86,72.25 217.86,71.33 217.64,71.11 212.66,71.11 v1(212.43,71.33) 209.56,74.2 209.33,74.2 208.57,74.96 208.57,75.32 208.39,75.5 208.04,75.5 207.31,76.23 207.31,76.5 206.97,76.85 206.69,76.85 202.9,80.64 196.9,80.64 196.71,80.83 195.44,80.83 195.16,81.12 195.16,82.69 194.6,83.25
  BOTTOM w0.127: v2(192.96,85.18) 192.56,85.58 U13.D13
VMA_DQ16: length 33.7
  IN3 w0.102: v2(193.84,83.61) 194.59,83.61 197.41,80.79
  IN3 w0.152: 197.41,80.79 197.53,80.67 202.98,80.67 211.26,72.39 213.61,72.39 213.85,72.15 216.23,72.15 216.95,72.87 216.95,73.49 217.42,73.96 217.42,75.21 217.97,75.75 v2(218.98,75.75)
  BOTTOM w0.127: v2(193.84,83.61) 194.22,84 U13.B15 ; v2(218.98,75.75) 219.25,75.75 VRAM4.D7
VMA_DQ17: length 34.3
  IN3 w0.152: v2(218.98,73.19) 218.54,72.74 218.54,72.16 217.25,70.86 210.56,70.86 202.44,78.98 197.44,78.98 196.83,79.59 v2(196.76,79.59)
  BOTTOM w0.127: v2(218.98,73.19) 219.09,73.19 VRAM4.A7 ; v2(196.76,79.59) 195.94,80.4 195.56,80.4 194.67,81.29 194.67,84.44 U13.C16
VMA_DQ18: length 36.4
  IN3 w0.102: 218.91,71.89 219.44,72.41 219.44,74.38 v2(219.9,74.84)
  IN3 w0.152: 218.91,71.89 217.44,70.41 210.37,70.41 202.25,78.52 197.14,78.52 v2(196.1,79.56)
  BOTTOM w0.102: VRAM4.C8 220.27,75.21 v2(219.9,74.84)
  BOTTOM w0.127: U13.A13 192.56,82.92 195.92,79.56 v2(196.1,79.56)
VMA_DQ19: length 35.9
  IN3 w0.102: 219.42,71.74 219.83,72.16 219.83,73.91 v2(219.92,74)
  IN3 w0.152: 219.42,71.74 217.63,69.95 210.18,69.95 202.07,78.07 196.93,78.07 194.24,80.76 v2(194.24,82.58)
  BOTTOM w0.127: v2(219.92,74) 220.32,74.4 VRAM4.B8 ; U13.A15 v2(194.24,82.58)
VMA_DQ20: length 33.8
  IN3 w0.152: v2(197.01,82.26) 197.09,82.33 197.98,82.33 198.26,82.05 205.01,82.05 205.41,81.66 205.62,81.66 206.02,82.05 206.23,82.05 206.45,81.83 206.45,81.62 206.06,81.23 206.06,81.01 206.27,80.79 206.49,80.79 206.88,81.19 207.1,81.19 207.31,80.97 207.31,80.76 206.92,80.36 206.92,80.15 207.13,79.93 207.35,79.93 207.74,80.33 207.96,80.33 208.17,80.11 208.17,79.89 207.78,79.5 207.78,79.28 208,79.07 208.21,79.07 208.61,79.46 208.82,79.46 209.04,79.25 209.04,79.03 208.64,78.64 208.64,78.42 208.86,78.21 209.07,78.21 209.47,78.6 209.68,78.6 209.9,78.38 209.9,78.17 209.51,77.78 209.51,77.56 210.95,76.11 211.17,76.11 211.48,76.43 211.7,76.43 211.92,76.22 211.92,76 211.6,75.68 211.6,75.47 211.81,75.25 212.03,75.25 212.35,75.57 212.56,75.57 212.78,75.35 212.78,75.14 212.46,74.82 212.46,74.6 212.89,74.18 213.39,74.18 214.05,73.52 214.8,73.52 v2(215.1,73.23)
  BOTTOM w0.127: U13.B18 196.32,83.61 196.32,82.94 v2(197.01,82.26) ; VRAM4.A2 215.12,73.22 215.12,73.23 v2(215.1,73.23)
VMA_DQ21: length 33.1
  IN3 w0.102: 216.34,76.69 216.34,76.03 v2(215.91,75.6)
  IN3 w0.152: 216.34,76.69 215.3,77.74 214.15,77.74 214,77.58 214,77.05 213.85,76.9 213.54,76.9 213.39,77.05 213.39,78.66 211.46,80.58 211.24,80.58 210.89,80.23 210.67,80.23 210.46,80.44 210.46,80.66 210.81,81.02 210.81,81.23 210.6,81.45 210.38,81.45 210.02,81.09 209.81,81.09 209.59,81.31 209.59,81.52 210.41,82.34 210.41,82.52 210.16,82.77 209.98,82.77 209.16,81.95 208.95,81.95 208.73,82.17 208.73,82.38 209.5,83.15 209.5,83.33 209.22,83.61 209.04,83.61 208.24,82.82 208.04,82.82 207.82,83.04 200.29,83.04 199.55,83.78 197.33,83.78 v2(197.12,83.58)
  BOTTOM w0.127: U13.A18 197.09,83.58 v2(197.12,83.58) ; v2(215.91,75.6) 215.52,75.21 VRAM4.C2
VMA_DQ22: length 32.3
  IN3 w0.152: v2(215.93,73.24) 215.49,72.8 214.19,72.8 213.29,73.7 212.48,73.7 212.13,74.05 211.91,74.05 211.53,73.67 211.31,73.67 211.1,73.88 211.1,74.1 211.48,74.48 211.48,74.7 211.26,74.91 211.05,74.91 210.67,74.53 210.45,74.53 210.24,74.75 210.24,74.96 210.62,75.34 210.62,75.56 210.4,75.77 210.19,75.77 209.81,75.39 209.59,75.39 209.37,75.61 209.37,75.82 209.76,76.21 209.76,76.42 209.51,76.67 209.29,76.67 208.9,76.27 208.69,76.27 208.47,76.49 208.47,76.7 208.86,77.1 208.86,77.31 208.65,77.53 208.43,77.53 208.04,77.13 207.82,77.13 207.61,77.35 207.61,77.57 208,77.96 208,78.18 207.78,78.39 207.57,78.39 207.18,78 206.96,78 206.74,78.21 206.74,78.43 207.14,78.82 207.14,79.04 204.59,81.58 197.81,81.58 v2(197.52,81.88)
  BOTTOM w0.127: U13.A19 v2(197.52,81.88) ; VRAM4.A3 216.31,73.62 v2(215.93,73.24)
VMA_DQ23: length 32.7
  IN3 w0.102: 213.34,75.47 213.7,75.12 213.88,75.12 214.58,74.41 215.5,74.41 v2(215.92,74.83)
  IN3 w0.152: 213.34,75.47 212.25,76.57 212.25,77.08 212.1,77.24 211.69,77.24 211.54,77.39 211.54,77.69 211.69,77.85 212.1,77.85 212.25,78 212.25,78.37 212.1,78.52 210.57,78.52 210.1,79 210.1,79.22 210.44,79.56 210.44,79.78 210.22,79.99 210.01,79.99 209.66,79.65 209.45,79.65 209.23,79.86 209.23,80.08 209.58,80.42 209.58,80.64 209.36,80.85 209.15,80.85 208.8,80.51 208.59,80.51 208.37,80.73 208.37,80.94 208.71,81.29 208.71,81.5 208.5,81.72 208.28,81.72 207.94,81.37 207.72,81.37 207.51,81.59 207.51,81.8 207.85,82.15 207.85,82.36 207.64,82.58 207.42,82.58 207.08,82.24 206.86,82.24 206.56,82.54 200.15,82.54 199.62,83.07 196.81,83.07 196.55,83.32 196.55,83.81 v2(197.14,84.39)
  BOTTOM w0.127: VRAM4.C3 215.93,74.83 v2(215.92,74.83) ; v2(197.14,84.39) 197.14,84.39 197.14,84.43 197.51,84.8 U13.C19
VMA_DQ24: length 35.5
  BOTTOM w0.127: VRAM4.G2 215.72,78.42 215.83,78.31 215.83,78.12 215.71,77.99 215.24,77.99 215.11,78.12 215.11,78.74 214.99,78.85 214.09,78.85 213.78,78.55 213.44,78.55 213.36,78.64 213.36,80.01 213.72,80.38 213.72,80.59 213.6,80.72 213.47,80.72 213.34,80.84 213.34,81.1 213.47,81.23 213.6,81.23 213.72,81.35 213.72,81.55 213.52,81.75 213.01,81.75 212.91,81.85 212.91,83.88 212.61,84.19 212.61,85.91 212.44,86.08 212.32,86.08 212.1,85.86 212.1,83.96 212.43,83.63 212.43,82.64 212.12,82.33 211.97,82.33 211.84,82.46 211.84,83.15 211.72,83.27 211.46,83.27 211.34,83.4 211.34,83.91 211.21,84.03 210.93,84.03 210.8,83.91 210.8,82.49 210.65,82.33 210.42,82.33 210.29,82.46 v1(210.29,83.02) 210.29,83.88 210.17,84.01 209.91,84.01 209.79,83.88 209.79,82.46 209.66,82.33 209.43,82.33 209.3,82.46 209.3,82.8 209.18,82.93 208.95,82.93 208.82,82.8 208.82,82.46 208.69,82.33 204.55,82.33 204.38,82.51 202.53,82.51 202.12,82.92 202.12,83.58 U13.B24
VMA_DQ25: length 37.1
  BOTTOM w0.127: VRAM4.E3 216.27,76.81 215.93,77.16 214.57,77.16 214.39,76.97 213.93,76.97 213.8,76.85 213.39,76.85 212.96,76.41 212.3,76.41 211.97,76.74 211.97,77.41 211.84,77.53 211.62,77.53 211.49,77.41 211.49,76.52 211.34,76.36 210.41,76.36 210.13,76.64 210.13,76.81 210.22,76.9 210.47,76.9 210.6,77.02 210.6,77.24 210.47,77.37 209.98,77.37 209.98,77.37 209.2,78.14 208.16,78.14 208.03,78.27 208.03,78.52 208.16,78.65 209.28,78.65 209.41,78.78 209.41,79.03 209.28,79.16 208.97,79.16 208.85,79.28 v1(208.85,79.87) 208.85,81.32 208.72,81.44 208.44,81.44 208.31,81.32 208.31,79.31 208.19,79.18 207.91,79.18 207.78,79.31 207.78,81.34 207.65,81.47 207.37,81.47 207.25,81.34 207.25,79.63 207.12,79.51 206.89,79.51 206.76,79.63 206.76,81.34 206.64,81.47 206.27,81.47 206.14,81.34 206.14,80.94 206.02,80.81 205.76,80.81 205.64,80.94 205.64,81.34 205.51,81.47 205.26,81.47 205.13,81.34 205.13,81.16 205,81.04 204.75,81.04 204.62,81.16 204.62,81.34 204.49,81.47 203.79,81.47 203.39,81.88 202.12,81.88 201.28,82.71 201.28,84.37 U13.C23
VMA_DQ26: length 33.3
  BOTTOM w0.127: VRAM4.H3 215.94,79.59 214.64,79.59 214.23,80 214.23,81.7 213.38,82.55 213.38,84.1 213.06,84.42 213.06,85.13 213.19,85.25 214.12,85.25 214.25,85.38 214.25,85.61 214.12,85.74 213.19,85.74 213.09,85.84 213.09,86.27 214.21,87.39 214.21,87.57 213.97,87.81 213.79,87.81 212.58,86.6 212.23,86.6 211.67,86.04 211.67,84.64 211.49,84.47 209.81,84.47 209.66,84.62 209.66,85 209.53,85.13 209.12,85.13 209,85 209,84.39 209.36,84.03 209.36,83.45 209.27,83.36 208.52,83.36 208.39,83.23 208.39,82.89 208.26,82.76 207.48,82.76 207.35,82.89 207.35,83.32 207.25,83.43 206.95,83.43 206.82,83.3 206.82,82.89 206.69,82.76 206.44,82.76 206.31,82.89 206.31,83.3 206.19,83.43 205.93,83.43 205.8,83.3 205.8,82.89 205.68,82.76 205.42,82.76 205.3,82.89 205.3,83.3 205.17,83.43 205.06,83.43 204.83,83.2 204.83,82.94 204.66,82.76 202.93,82.76 202.69,83.01
  BOTTOM w0.381: U13.A25 202.69,83.01
VMA_DQ27: length 34.6
  BOTTOM w0.127: U13.A24 201.7,82.86 202.32,82.23 203.82,82.23 204.15,81.9 211.97,81.9 212.1,81.77 212.1,81.49 211.97,81.37 209.51,81.37 v1(209.41,81.27) 209.41,80.89 209.53,80.76 211.72,80.76 211.84,80.63 211.84,80.33 211.72,80.2 210.04,80.2 209.84,80 209.84,78.12 210.16,77.8 210.63,77.8 210.83,78 211.31,78 211.44,78.13 211.44,78.7 211.56,78.83 211.79,78.83 211.92,78.7 211.92,78.13 212.05,78 212.25,78 212.38,78.13 212.38,80.76 212.5,80.89 212.76,80.89 212.89,80.76 212.89,78.09 213.18,77.8 214.23,77.8 214.41,77.98 214.85,77.98 215.22,77.62 VRAM4.F2
VMA_DQ28: length 36.6
  BOTTOM w0.127: U13.A21 199.2,83.04 201.68,80.55 201.79,80.55 208.13,74.21 208.31,74.21 208.63,74.54 208.85,74.54 209.01,74.37 209.01,74.19 208.67,73.85 208.67,73.67 208.85,73.49 209.03,73.49 209.66,74.13 209.81,74.13 210.02,73.92 210.02,73.77 209.39,73.13 209.39,72.95 209.57,72.77 209.75,72.77 210.29,73.32 210.47,73.32 210.65,73.14 210.65,72.96 v1(210.36,72.67) 210.11,72.42 210.11,72.24 210.52,71.82 210.83,71.82 210.95,71.94 210.95,72.55 211.08,72.68 211.26,72.68 211.26,72.68 211.62,72.68 211.62,72.68 212.28,72.68 212.4,72.55 212.4,71.87 212.53,71.74 217.53,71.74 218.47,72.68 218.47,77.18 218.91,77.62 VRAM4.F7
VMA_DQ29: length 37.3
  BOTTOM w0.102: U13.B21 199.2,83.69 198.86,83.34 198.86,83.05 199.53,82.38 199.53,82.21
  BOTTOM w0.127: VRAM4.F8 220.32,77.91 220.44,78.04 220.61,78.04 220.73,77.91 220.73,77.33 220.86,77.2 221.34,77.2 221.95,76.59 221.95,73.85 220.74,72.64 219.8,72.64 218.47,71.31 212.07,71.31 211.93,71.45 211.93,72.1 211.81,72.22 211.53,72.22 211.4,72.1 211.4,71.51 211.27,71.39 210.35,71.39 199.53,82.21
VMA_DQ30: length 41.7
  BOTTOM w0.102: VRAM4.H7 219.85,79.55 221.61,79.55 222.39,78.77 222.39,73.54 ; 198.63,81.82 198.02,82.43 198.02,84.46 U13.C20
  BOTTOM w0.127: 222.39,73.54 219.29,70.45 210,70.45 198.63,81.82
VMA_DQ31: length 38.8
  BOTTOM w0.102: 199.25,81.82 199.25,82.38 198.65,82.97 198.65,83.43 198.86,83.63 198.86,84.46 U13.C21 ; VRAM4.H8 220.78,78.75 221.25,78.75 221.47,78.52 221.79,78.52 222.17,78.15 222.17,73.71
  BOTTOM w0.127: 222.17,73.71 220.86,72.4 220.48,72.4 218.96,70.88 211.18,70.88 211.11,70.95 210.12,70.95 199.25,81.82
VMA_DQ32: length 43.6
  TOP w0.102: 201.79,100.44 201.68,100.34 201.68,97.45 201.46,97.22 201.13,97.22 200.92,97.01 200.92,96.58 200.69,96.35 200.31,96.35 200.07,96.11 200.07,95.55 v2(200.48,95.14)
  TOP w0.127: 201.79,100.44 204.22,102.88 204.22,103.47 205.14,104.38 205.14,109.92 210.29,115.07 v1(212.17,115.07) 217.43,115.07 221.94,110.56 221.94,109.19 221.45,108.7 220.91,108.7 220.71,108.49 220.71,108.06 220.51,107.86 219.97,107.86 219.58,107.47 VRAM1.D7
  BOTTOM w0.127: v2(200.48,95.14) 200.08,94.74 U13.R22
VMA_DQ33: length 36.4
  TOP w0.102: v2(202.12,95.14) 202.27,95.29 203.16,95.29 203.43,95.56 204.73,95.56 204.74,95.57 204.78,95.57 205.06,95.85 205.06,96.38
  TOP w0.127: VRAM1.A7 219.16,110.23 219.16,110.7 216.47,113.4 210.45,113.4 206.43,109.38 206.43,102.45 205.47,101.48 205.47,100.49 205.34,100.37 204.99,100.37 204.86,100.24 204.86,99.96 204.99,99.83 205.39,99.83 205.52,99.71 205.52,99.45 205.39,99.33 204.99,99.33 204.86,99.2 204.86,98.92 204.99,98.79 205.34,98.79 205.47,98.67 205.47,98.08 205.06,97.67 v1(205.06,96.89) 205.06,96.38
  BOTTOM w0.127: U13.R24 202.1,95.14 v2(202.12,95.14)
VMA_DQ34: length 38.4
  TOP w0.102: v2(200.48,95.94) 200.65,95.94 201.1,96.39 202.26,96.39 202.34,96.48 202.34,98.09 202.5,98.24 202.5,99.06 202.52,99.09 202.52,99.43 202.52,99.43 202.52,100.11 202.85,100.44
  TOP w0.127: 202.85,100.44 204.53,102.12 204.74,102.12 205.57,102.95 205.57,109.74 210.17,114.34 v1(210.63,114.34) 216.85,114.34 220.66,110.53 220.66,108.89 220.45,108.69 220.45,108.41 VRAM1.C8
  BOTTOM w0.127: v2(200.48,95.94) 200.08,95.54 U13.T22
VMA_DQ35: length 39.3
  TOP w0.102: 204.17,96.7 203.85,96.38 203.09,96.38 203.09,96.37 202.75,96.37 201.51,95.14 v2(201.3,95.14)
  TOP w0.127: VRAM1.B8 219.91,109.48 219.91,110.03 219.52,110.43 219.52,110.96 216.65,113.83 210.63,113.83 210.27,113.83 206,109.56 206,102.63 205.02,101.65 205.02,101 204.9,100.87 v1(204.38,100.87) 203.92,100.87 203.79,100.74 203.79,100.49 203.92,100.36 204.25,100.36 204.38,100.24 204.38,100.01 204.25,99.88 203.49,99.88 203.36,99.76 203.36,99.53 203.49,99.4 204.2,99.4 204.33,99.27 204.33,98.69 204.21,98.58 204.21,96.74 204.17,96.7
  BOTTOM w0.127: U13.R23 v2(201.3,95.14)
VMA_DQ36: length 40.7
  TOP w0.102: 204.91,93.46 204.48,93.46 204.25,93.23 203.18,93.23 202.9,92.95 202.9,92.67 202.9,92.67 v2(202.89,92.67)
  TOP w0.127: 204.91,93.46 205.88,93.46 208.54,96.12 210.4,96.12 210.52,96.25 210.52,96.5 210.4,96.63 208.95,96.63 208.82,96.75 208.82,97.01 208.95,97.13 209.41,97.13 209.53,97.26 209.53,97.52 209.41,97.64 208.95,97.64 208.82,97.77 208.82,98.02 208.95,98.15 209.41,98.15 209.53,98.28 209.53,98.53 209.41,98.66 208.95,98.66 208.82,98.79 208.82,99.04 208.95,99.17 209.41,99.17 209.53,99.29 209.53,99.55 209.41,99.67 208.95,99.67 208.82,99.8 208.82,100.06 208.95,100.18 209.41,100.18 209.53,100.31 209.53,107.22 209.66,107.35 v1(210.5,107.35) 211.69,107.35 212.02,107.68 212.02,109.66 213.27,110.91 215.06,110.91 215.87,110.1 215.87,108.02 216.02,107.87 216.99,107.87 217.14,108.02 217.14,108.44 216.99,108.59 216.47,108.59 216.32,108.44 VRAM1.C3
  BOTTOM w0.127: U13.N25 202.51,93.06 202.9,92.67 v2(202.89,92.67)
VMA_DQ37: length 40
  TOP w0.102: v2(203.71,92.64) 204.3,92.64 204.81,93.15 206.33,93.15 206.36,93.19
  TOP w0.127: VRAM1.A2 214.73,110.65 213.65,110.65 212.58,109.59 v1(212.58,109.18) 212.58,108.75 212.45,108.62 212.45,107.38 211.87,106.79 211.87,102.8 212,102.68 212.5,102.68 212.63,102.55 212.63,102.3 212.5,102.17 212,102.17 211.87,102.04 211.87,101.79 212,101.66 212.5,101.66 212.63,101.53 212.63,101.28 212.5,101.15 212,101.15 211.87,101.03 211.87,100.77 212,100.65 212.5,100.65 212.63,100.52 212.63,100.26 212.5,100.14 212,100.14 211.87,100.01 211.87,99.59 212,99.46 212.48,99.46 212.61,99.34 212.61,99.08 212.48,98.96 212,98.96 211.87,98.83 211.87,98.57 212,98.45 212.48,98.45 212.61,98.32 212.61,98.07 212.48,97.94 212,97.94 211.87,97.81 211.87,94.75 211.69,94.58 211.3,94.58 211.17,94.7 211.17,95.74 211.04,95.87 210.79,95.87 210.66,95.74 210.66,94.7 210.53,94.58 210.14,94.58 210.02,94.7 210.02,95.41 209.89,95.54 209.64,95.54 209.51,95.41 209.51,94.7 209.38,94.58 209.13,94.58 209,94.7 209,95.41 208.87,95.54 208.62,95.54 208.49,95.41 208.49,94.7 208.37,94.58 207.75,94.58 206.36,93.19
  BOTTOM w0.127: v2(203.71,92.64) 203.7,92.64 203.3,93.05 U13.N26
VMA_DQ38: length 42.3
  TOP w0.102: 206.36,92.7 205.9,92.24 203.09,92.24 203.07,92.26 202.73,92.26 202.71,92.24 201.73,92.24 v2(201.3,92.67)
  TOP w0.127: VRAM1.C2 215.11,108.67 214.57,108.67 214.21,109.03 214.1,109.03 213.47,109.03 212.89,108.44 212.89,106.98 212.76,106.85 212.56,106.85 212.43,106.72 212.43,106.47 212.56,106.34 212.76,106.34 212.89,106.21 212.89,105.9 212.76,105.78 212.43,105.78 212.3,105.65 212.3,103.59 213.09,102.81 213.09,97.58 212.96,97.46 212.45,97.46 212.33,97.33 212.33,97.08 212.45,96.95 213.6,96.95 213.72,96.82 213.72,96.57 213.6,96.44 212.45,96.44 212.33,96.31 212.33,96.06 212.45,95.93 214.16,95.93 214.28,95.81 214.28,95.55 214.16,95.43 212.45,95.43 212.33,95.3 212.33,95.04 212.45,94.92 v1(212.96,94.92) 214.36,94.92 214.49,94.79 214.49,94.27 214.36,94.14 207.93,94.14 206.48,92.7 206.36,92.7
  BOTTOM w0.127: U13.N23 201.29,92.67 v2(201.3,92.67)
VMA_DQ39: length 41.9
  TOP w0.102: v2(202.12,92.67) 202.12,93.2 202.42,93.51 204.11,93.51 204.51,93.92 204.66,93.92
  TOP w0.127: 204.66,93.92 205.72,93.92 208.39,96.58 208.39,100.88 208.52,101.01 v1(208.72,101.01) 208.98,101.01 209.1,101.13 209.1,101.39 208.97,101.51 208.52,101.51 208.39,101.64 208.39,101.99 208.52,102.12 209,102.12 209.1,102.22 209.1,102.52 209,102.63 208.52,102.63 208.39,102.75 208.39,103.01 208.52,103.13 209,103.13 209.1,103.24 209.1,103.54 209,103.64 208.52,103.64 208.39,103.77 208.39,104.02 208.52,104.15 208.95,104.15 209.08,104.28 209.08,104.53 208.95,104.66 208.52,104.66 208.39,104.79 208.39,105.04 208.52,105.17 208.97,105.17 209.1,105.29 209.1,105.55 208.97,105.67 208.52,105.67 208.39,105.8 208.39,106.06 208.52,106.18 208.97,106.18 209.1,106.31 209.1,106.56 208.97,106.69 208.52,106.69 208.39,106.82 208.39,107.28 208.62,107.51 208.8,107.51 208.84,107.47 209.02,107.47 209.19,107.65 209.19,107.83 209.16,107.86 209.16,108.04 209.34,108.22 209.52,108.22 209.96,107.78 210.24,107.78 210.37,107.91 210.37,108.09 209.88,108.58 209.88,108.76 210.06,108.94 210.24,108.94 211.28,107.9 211.46,107.9 211.59,108.04 211.59,108.31 210.6,109.3 210.6,109.48 210.73,109.61 211.36,109.61 213.14,111.39 215.43,111.39 216.32,110.5 VRAM1.A3
  BOTTOM w0.127: v2(202.12,92.67) 201.72,93.06 U13.N24
VMA_DQ40: length 34.2
  TOP w0.152: VRAM1.E3 216.32,106.64 v2(215.91,106.23)
  IN1 w0.102: 204.45,97.12 204.36,97.21 202.58,97.21 202.24,97.55 201.35,97.55 v2(201.28,97.62)
  IN1 w0.114: v2(215.91,106.23) 215.5,106.65 215.5,107.36 214.71,108.14 214.71,108.93 214.49,109.16 213.65,109.16 213.52,109.03 213.52,108.48 213.39,108.36 212.91,108.36 212.81,108.46 212.81,109.92 212.68,110.04 212.5,110.04 212.37,109.92 212.37,109.35 208.98,105.96 208.98,104.29 207.53,102.85 207.53,100.64 207.37,100.47 207.37,100.2 207.53,100.04 207.53,99.84 207.4,99.71 207.24,99.71 207.03,99.92 206.85,99.92 206.7,99.77 206.7,99.59 207.44,98.86 207.44,98.68 207.3,98.54 207.12,98.54 206.37,99.28 206.19,99.28 206.04,99.14 206.04,98.96 206.79,98.21 206.79,98.03 206.65,97.89 206.47,97.89 205.76,98.59 205.6,98.59 205.44,98.43 205.44,98.27 205.62,98.09 205.62,97.93 204.81,97.12 204.45,97.12
  BOTTOM w0.127: v2(201.28,97.62) 200.9,97.24 U13.V23
VMA_DQ41: length 34.4
  TOP w0.152: VRAM1.G2 215.51,105.1 v2(215.13,105.48)
  IN1 w0.102: 204.24,96.7 203.93,96.39 203.33,96.39 203.31,96.37 202.6,96.37 201.76,97.22 200.87,97.22 v2(200.49,97.6)
  IN1 w0.114: v2(215.13,105.48) 214.62,105.99 214.62,107.52 214.21,107.94 211.62,107.94 209.4,105.72 209.4,104.12 207.96,102.68 207.96,102.36 208.07,102.24 208.61,102.24 208.72,102.13 208.72,101.9 208.61,101.79 208.07,101.79 207.96,101.67 207.96,101.44 208.07,101.33 208.61,101.33 208.72,101.21 208.72,100.99 208.61,100.87 208.07,100.87 207.96,100.76 207.96,100.53 208.07,100.41 208.61,100.41 208.72,100.3 208.72,100.07 208.61,99.96 208.07,99.96 207.96,99.84 207.96,99.51 208.07,99.4 208.63,99.4 208.75,99.29 208.75,99.06 208.63,98.94 208.07,98.94 207.96,98.83 207.96,98.13 207.25,97.42 206.66,97.42 206.54,97.29 206.54,96.82 206.41,96.7 206.16,96.7 206.05,96.81 206.05,97.28 205.94,97.4 205.71,97.4 205.59,97.28 205.59,96.1 205.47,95.97 205.16,95.97 205.04,96.1 205.04,96.57 204.91,96.7 204.24,96.7
  BOTTOM w0.127: v2(200.49,97.6) 200.11,97.22 U13.V22
VMA_DQ42: length 35.8
  TOP w0.127: v2(213.5,106.87) 213.75,106.61 214.27,106.61 214.57,106.32 214.58,106.32 214.6,106.3 215.09,106.3 VRAM1.F2
  IN1 w0.102: v2(201.32,95.99) 202.25,95.99 202.71,95.53 203.54,95.53 203.55,95.55 203.89,95.55 203.89,95.54 204.83,95.54
  IN1 w0.114: v2(213.5,106.87) 213.5,106.13 213.37,106.01 213.08,106.01 212.96,106.13 212.96,107.38 212.83,107.5 212.62,107.5 212.5,107.38 212.5,105.8 212.37,105.68 212.17,105.68 212.04,105.8 212.04,107.26 211.93,107.38 211.67,107.38 211.34,107.05 211.34,106.89 211.61,106.62 211.61,106.46 211.45,106.3 211.29,106.3 211.02,106.57 210.86,106.57 209.93,105.64 209.93,103.99 209.18,103.24 209.18,98.63 209.07,98.52 208.5,98.52 208.39,98.4 208.39,98.18 208.5,98.06 209.07,98.06 209.18,97.95 209.18,97.72 209.07,97.6 208.03,97.6 207.91,97.48 207.91,97.27 208.03,97.15 209.07,97.15 209.18,97.03 209.18,96.74 208.99,96.54 207.74,96.54 207.4,96.89 207.09,96.89 206.97,96.76 206.97,96.35 206.84,96.22 206.15,96.22 206.03,96.1 206.03,95.67 205.9,95.54 204.83,95.54
  BOTTOM w0.127: v2(201.32,95.99) 201.33,95.99 201.33,95.95 200.92,95.54 U13.T23
VMA_DQ43: length 36
  TOP w0.152: VRAM1.H3 215.96,103.92 215.37,103.92 215.13,104.15 215.13,104.36 214.86,104.63 214.49,104.63 214.26,104.4 213.9,104.4 213.47,104.82 v2(213.47,105.55)
  IN1 w0.102: 203.14,94.73 202.28,95.58 201.15,95.58 200.89,95.84 200.89,96.41 v2(200.52,96.79)
  IN1 w0.114: 203.14,94.73 205.97,94.73 207.37,96.13 209.2,96.13 209.6,96.53 209.6,101.56 209.73,101.69 210.52,101.69 210.65,101.81 210.65,102.04 210.52,102.17 209.76,102.17 209.63,102.3 209.63,102.5 209.76,102.63 210.24,102.63 210.35,102.73 210.35,103.38 210.46,103.5 210.79,103.5 210.9,103.61 210.9,103.84 210.79,103.95 210.46,103.95 210.35,104.07 210.35,105.35 210.48,105.47 211.34,105.47 211.46,105.35 211.46,104.58 211.59,104.46 211.77,104.46 211.9,104.58 211.9,105.09 212.02,105.22 212.23,105.22 212.35,105.09 212.35,104.53 212.48,104.41 212.68,104.41 212.81,104.53 212.81,105.09 212.94,105.22 213.11,105.22 213.24,105.09 213.24,104.56 213.37,104.43 213.56,104.43 213.69,104.56 213.69,105.33 v2(213.47,105.55)
  BOTTOM w0.127: v2(200.52,96.79) 200.11,96.38 U13.U22
VMA_DQ44: length 33.5
  TOP w0.152: v2(218.93,106.75) 218.93,105.96 219.18,105.71 219.18,105.26 219.11,105.19 219.11,104.84 219.51,104.44 VRAM1.H7
  IN1 w0.114: v2(218.93,106.75) 218.93,107.43 218.67,107.69 217.84,107.69 216.59,108.95 216.59,110.69 215.18,112.1 211.54,112.1 206.54,107.1 206.54,106.91 206.65,106.79 206.88,106.79 206.99,106.68 206.99,106.45 206.88,106.34 206.65,106.34 206.54,106.22 206.54,105.99 206.65,105.88 206.88,105.88 206.99,105.76 206.99,105.54 206.88,105.42 206.65,105.42 206.54,105.31 206.54,104.53 205.61,103.61 205.61,103.01 205.33,102.74 205.33,102.58 205.63,102.28 205.63,102.12 205.46,101.96 205.3,101.96 205.01,102.25 204.69,102.25 202.95,100.52 202.95,100.1 v2(202.12,99.26)
  BOTTOM w0.127: U13.Y24 201.72,98.86 v2(202.12,99.26)
VMA_DQ45: length 33.4
  TOP w0.152: v2(219.92,106.26) 219.9,106.26 VRAM1.F7
  IN1 w0.114: v2(219.92,106.26) 219.5,106.68 219.5,107.86 218.68,108.68 218.68,109.28 218.43,109.53 218.26,109.53 218.14,109.41 218.14,108.49 218.02,108.37 217.8,108.37 217.67,108.49 217.67,109.58 217.94,109.85 217.94,110.01 217.78,110.17 217.62,110.17 217.35,109.91 217.19,109.91 217.03,110.07 217.03,110.23 217.29,110.5 217.29,110.66 215.39,112.56 211.39,112.56 206.12,107.29 206.12,104.75 205.19,103.82 205.19,103.19 204.76,102.75 204.58,102.75 202.09,100.27 v2(202.09,100.09)
  BOTTOM w0.127: U13.AA24 201.7,99.7 v2(202.09,100.09)
VMA_DQ46: length 33.6
  TOP w0.152: VRAM1.F8 220.34,105.87 220.73,106.27 v2(220.74,106.27)
  IN1 w0.102: 220.35,107.35 220.35,106.65 v2(220.74,106.27) ; v2(200.47,99.25) 200.66,99.25 201.11,99.7 201.47,99.7 201.68,99.91 201.68,100.21
  IN1 w0.114: 201.68,100.21 201.68,100.34 202.31,100.97 202.31,101.31 204.07,103.07 204.07,103.33 205.7,104.96 205.7,107.5 211.21,113.02 215.53,113.02 219.1,109.45 219.1,108.86 219.7,108.25 220.41,108.25 220.68,107.98 220.68,107.68 220.35,107.35
  BOTTOM w0.127: U13.Y22 200.45,99.25 v2(200.47,99.25)
VMA_DQ47: length 36.9
  TOP w0.152: v2(222.46,105.52) 222.46,104.86 221.48,103.88 220.71,103.88 VRAM1.H8
  IN1 w0.114: v2(222.46,105.52) 221.83,106.16 221.62,106.16 221.24,106.54 221.24,108.01 215.81,113.45 211.03,113.45 205.27,107.68 205.27,105.12 203.64,103.49 203.64,103.29 202.01,101.66 202.01,100.98 201.28,100.24 v2(201.28,100.1)
  BOTTOM w0.127: v2(201.28,100.1) 201.28,100.1 200.9,99.72 U13.AA23
VMA_DQ48: length 33.1
  BOTTOM w0.127: VRAM3.C3 219.51,108.42 219.15,108.78 219.15,109.32 219.29,109.46 219.62,109.46 219.92,109.77 219.92,110.02 219.54,110.4 219.54,110.83 219.76,111.05 220.59,111.05 220.84,111.29 220.84,111.9 218.12,114.62 209.63,114.62 209.06,114.04 208.86,114.04 207.88,113.07 207.88,107.4 205.57,105.09 205.57,102.83 204.94,102.2 U13.AD27
VMA_DQ49: length 35
  BOTTOM w0.102: U13.AB25 202.5,100.8 202.88,101.18 202.88,101.51 203.23,101.86 203.44,101.86 203.55,101.97 203.84,101.97 203.96,101.86 204.32,101.86 204.44,101.98 205.23,101.98 205.58,102.34
  BOTTOM w0.127: 205.58,102.34 206,102.75 206,104.91 208.31,107.22 208.31,112.64 v1(208.75,113.07) 209.86,114.18 217.94,114.18 218.66,113.46 218.66,113.28 218.33,112.96 218.33,112.78 218.51,112.6 218.69,112.6 219.02,112.93 219.2,112.93 219.38,112.75 219.38,112.57 219.09,112.28 219.09,112.1 219.27,111.92 219.45,111.92 219.74,112.21 219.92,112.21 220.23,111.9 220.23,111.61 220.1,111.48 219.11,111.48 218.98,111.35 218.98,110 219.11,109.87 VRAM3.A3
VMA_DQ50: length 32.5
  BOTTOM w0.127: VRAM3.A2 220.56,109.87 220.89,110.2 220.89,110.73 221.06,110.91 221.42,110.91 221.5,110.98 221.5,111.85 218.3,115.05 209.25,115.05 v1(208.85,114.64) 207.45,113.24 207.45,107.58 205.14,105.27 205.14,102.83 204.86,102.55 204.33,102.55 204.24,102.64 203.99,102.64 203.56,102.2 U13.AD26
VMA_DQ51: length 36.3
  BOTTOM w0.127: U13.AC25 202.5,101.5 202.91,101.91 202.91,102.33 203.23,102.64 203.45,102.64 203.69,102.89 203.69,103.14 204,103.44 204.25,103.44 204.53,103.73 204.53,105.27 207.02,107.76 207.02,113.55 v1(207.63,114.16) 208.95,115.48 218.5,115.48 221.94,112.04 221.94,109.29 221.34,108.7 220.74,108.7 VRAM3.C2
VMA_DQ52: length 33.3
  BOTTOM w0.127: U13.AA27 208.06,99.7 208.19,99.57 208.19,98.28 208.31,98.16 208.58,98.16 208.71,98.28 208.71,100.13 208.58,100.26 207.27,100.26 207.15,100.38 207.15,100.64 207.27,100.76 208.58,100.76 208.71,100.89 208.71,101.14 208.58,101.27 208.24,101.27 208.11,101.4 208.11,101.65 208.24,101.78 208.58,101.78 208.71,101.91 208.71,104.15 210.93,106.37 v1(210.93,106.82) 210.93,107.05 211.11,107.22 212.05,107.22 212.17,107.35 212.17,107.71 212.05,107.83 211.82,107.83 211.69,107.96 211.69,108.27 211.82,108.4 212.3,108.4 212.43,108.52 212.43,108.78 212.3,108.9 211.82,108.9 211.69,109.03 211.69,109.28 211.82,109.41 212.71,109.41 212.83,109.54 212.83,109.79 212.71,109.92 211.82,109.92 211.69,110.05 211.69,110.33 211.84,110.48 213.61,110.48 213.91,110.78 215.45,110.78 215.88,110.35 215.88,109.44 VRAM3.B8
VMA_DQ53: length 33.5
  BOTTOM w0.127: U13.AA26 203.68,100.08 205.88,100.08 207.96,102.16 207.96,104.01 210.29,106.35 210.29,111.62 210.42,111.75 210.63,111.75 210.75,111.62 210.75,107.78 210.88,107.66 211.14,107.66 211.26,107.78 211.26,112.1 211.39,112.23 v1(211.49,112.23) 211.62,112.23 211.74,112.1 211.74,111.03 211.87,110.91 213.43,110.91 213.85,111.33 216.27,111.33 216.52,111.09 216.52,110.07 VRAM3.A7
VMA_DQ54: length 35.7
  BOTTOM w0.102: 213.32,108.1 214.2,108.1 214.38,107.91 215.87,107.91 VRAM3.D7
  BOTTOM w0.127: 213.32,108.1 213.05,107.83 213.05,105.45 212.54,104.94 210.75,104.94 209.57,103.76 209.57,95.62 209.44,95.49 v1(208.39,95.49) 207.59,95.49 207.46,95.36 207.46,94.86 207.34,94.73 207.08,94.73 206.96,94.86 206.96,95.36 206.83,95.49 206.36,95.49 206.23,95.36 206.23,94.91 206.1,94.78 205.67,94.78 205.54,94.91 205.54,96.09 205.67,96.21 208.11,96.21 208.24,96.34 208.24,96.59 208.11,96.72 205.67,96.72 205.54,96.85 205.54,98.6 205.3,98.84 204.56,98.84 204.18,98.45 203.73,98.45 U13.W26
VMA_DQ55: length 35.8
  BOTTOM w0.102: 214.31,108.93 214.51,108.73 215.06,108.73 VRAM3.C8
  BOTTOM w0.127: 214.31,108.93 214.16,109.08 213.6,109.08 212.62,108.1 212.62,105.62 212.44,105.45 v1(211.9,105.45) 210.62,105.45 209.14,103.97 209.14,96.07 209.01,95.95 208.82,95.95 208.69,96.07 208.69,97.57 208.57,97.7 208.36,97.7 208.24,97.57 208.24,97.32 208.11,97.19 206.1,97.19 205.97,97.32 205.97,97.59 206.1,97.72 207.65,97.72 207.78,97.84 207.78,98.1 207.65,98.22 206.1,98.22 205.97,98.35 205.97,98.61 206.1,98.74 207.6,98.74 207.73,98.87 207.73,99.14 207.6,99.27 204.29,99.27 204.22,99.34 203.95,99.34 203.82,99.47 203.58,99.47 203.45,99.34 202.99,99.34 202.51,98.86 U13.Y25
VMA_DQ56: length 32.1
  IN3 w0.102: v2(203.72,95.14) 203.39,94.81 203.39,94.17 203.3,94.08 203.3,92.21 203.45,92.06 203.45,91.67
  IN3 w0.152: v2(216.69,104.68) 215.61,103.59 214.84,103.59 214.59,103.34 213.08,103.34 211.13,101.39 211.13,101.23 209.81,99.91 209.81,99.36 208.47,98.01 208.47,93.61 208.21,93.35 208.21,89.27 207.83,88.89 206.69,88.89 206.28,89.29 204.28,89.29 203.45,90.12 203.45,91.67
  BOTTOM w0.127: U13.R26 203.7,95.14 v2(203.72,95.14)
  BOTTOM w0.14: v2(216.69,104.68) 216.32,104.3 VRAM3.H7
VMA_DQ57: length 32.6
  IN3 w0.102: v2(215.07,107.07) 214.59,106.59 213.83,106.59 213.09,105.84 ; v2(202.9,95.94) 202.9,95.85 203.19,95.56 204.74,95.56
  IN3 w0.152: 204.74,95.56 205.01,95.29 205.01,93.79 205.14,93.66 205.52,93.66 205.65,93.79 205.65,94.43 205.77,94.56 206.1,94.56 206.21,94.45 206.21,92.09 206.33,91.96 206.33,91.12 206.46,90.99 206.71,90.99 206.84,91.12 206.84,94.93 207.09,95.19 207.09,98.58 208.44,99.92 208.44,100.48 209.71,101.75 209.71,102.63 210.12,103.03 210.12,103.33 210.57,103.78 210.57,104.76 211.26,105.45 212.69,105.45 213.09,105.84
  BOTTOM w0.127: U13.T25 v2(202.9,95.94)
  BOTTOM w0.14: VRAM3.F8 215.07,106.32 v2(215.07,107.07)
VMA_DQ58: length 31.7
  IN3 w0.102: v2(205.01,92.72) 204.28,92.72 204.15,92.59 204.15,92.42 204.28,92.29 204.46,92.29 204.58,92.17 204.58,91.91 204.35,91.68 204.35,91.02 204.3,90.97 204.05,90.97 203.91,90.83 203.91,90.79
  IN3 w0.152: v2(215.91,105.49) 215.43,105.01 215.43,104.23 215.3,104.1 214.23,104.1 213.85,104.48 212.53,104.48 212.38,104.33 212.38,103.95 212.61,103.72 212.61,103.51 212.23,103.13 211.92,103.13 211.79,103.01 211.79,102.7 211.6,102.5 210.88,102.5 210.63,102.25 210.63,101.37 209.36,100.1 209.36,99.55 208.01,98.2 208.01,94.81 207.75,94.55 207.75,94.27 208.01,94.02 208.01,93.8 207.75,93.54 207.75,89.96 207.54,89.75 204.5,89.75 203.91,90.35 203.91,90.79
  BOTTOM w0.127: U13.N27 204.67,93.06 v2(205.01,92.72)
  BOTTOM w0.14: v2(215.91,105.49) 215.93,105.49 VRAM3.F7
VMA_DQ59: length 32.7
  IN3 w0.152: v2(214.1,104.91) 214.02,104.99 211.82,104.99 211.64,104.81 211.64,104.48 211.92,104.2 211.92,103.8 211.54,103.42 210.86,103.42 210.57,103.14 210.57,102.84 210.17,102.44 210.17,101.56 208.9,100.29 208.9,99.74 207.55,98.39 207.55,95 207.3,94.74 207.3,90.38 207.12,90.21 204.73,90.21 204.61,90.33 204.61,90.61 204.73,90.74 205.62,90.74 205.85,90.97 205.85,91.73 205.52,92.06 205.52,92.37 205.75,92.59 205.75,93.05 205.62,93.18 204.02,93.18 203.89,93.31 203.89,93.53 204.05,93.69 204.4,93.69 204.5,93.79 v2(204.5,95.14)
  BOTTOM w0.127: v2(204.5,95.14) 204.1,94.74 U13.R27
  BOTTOM w0.14: v2(214.1,104.91) 214.37,104.64 214.93,104.64 215.29,104.27 VRAM3.H8
VMA_DQ60: length 31.9
  IN3 w0.102: v2(219.92,105.45) 219.92,105.66 219.52,106.07 219.52,106.43 219.54,106.45 219.54,107.01 219.32,107.23 219.32,108.32 218.98,108.66 218.98,108.75
  IN3 w0.152: 218.98,108.75 217.15,110.58 211.27,110.58 204.16,103.47 204.16,103.21 203.34,102.39 203.34,102.16 203.49,102 203.89,102 204.05,101.85 204.05,101.55 203.89,101.39 203.49,101.39 203.34,101.24 203.34,100.94 203.49,100.79 203.89,100.79 204.05,100.63 204.05,100.33 203.89,100.18 203.49,100.18 203.34,100.02 203.34,98.79 203.71,98.42 v2(203.71,97.64)
  BOTTOM w0.102: v2(219.92,105.45) 220.32,105.84 VRAM3.F2
  BOTTOM w0.127: v2(203.71,97.64) 203.3,97.23 U13.V26
VMA_DQ61: length 30.3
  IN3 w0.102: 218.43,108.93 219.12,108.24 219.12,107.14 219.34,106.92 219.34,106.54 219.31,106.51 219.31,106.01 v2(218.74,105.44)
  IN3 w0.152: 218.43,108.93 218.12,108.93 216.92,110.12 211.72,110.12 205.18,103.58 205.18,102.88 205.02,102.72 204.5,102.72 204.35,102.57 204.35,102.27 204.5,102.11 205.02,102.11 205.18,101.96 205.18,101.4 204.62,100.84 204.62,98.6 204.52,98.5 204.52,97.71 v2(204.63,97.6)
  BOTTOM w0.127: v2(204.63,97.6) 204.25,97.22 U13.V27 ; v2(218.74,105.44) 218.74,105.05 VRAM3.H3
VMA_DQ62: length 29.7
  IN3 w0.102: 213.09,109.4 213.24,109.24 214.55,109.24 214.99,109.69 215.88,109.69 216.98,108.6 218.18,108.6 v2(218.67,108.11)
  IN3 w0.152: 213.09,109.4 212.82,109.66 211.92,109.66 206.98,104.73 206.98,104.51 207.47,104.03 207.47,103.81 207.25,103.6 207.04,103.6 206.55,104.08 206.34,104.08 205.63,103.38 205.63,103.1 205.79,102.94 207.32,102.94 207.48,102.79 207.48,102.49 207.32,102.34 205.79,102.34 205.63,102.18 205.63,101.21 205.08,100.65 205.08,98.37 v2(205.01,98.3)
  BOTTOM w0.127: VRAM3.E3 219.39,106.8 219.39,107.07 218.67,107.79 v2(218.67,108.11) ; v2(205.01,98.3) 204.73,98.02 U13.W27
VMA_DQ63: length 30.4
  IN3 w0.102: v2(220.69,105.45) 220.33,105.81 220.33,106.44 220.35,106.46 220.35,107.63 219.44,108.55 219.44,108.94 218.54,109.84
  IN3 w0.152: 218.54,109.84 217.34,111.03 211.08,111.03 203.7,103.66 203.7,103.4 202.85,102.55 202.85,98.51 v2(202.93,98.44)
  BOTTOM w0.102: VRAM3.G2 220.32,105.08 v2(220.69,105.45)
  BOTTOM w0.127: v2(202.93,98.44) 202.51,98.02 U13.W25
VMA_RDQS0: length 32.7
  TOP w0.127: VRAM2.B7 216.56,74.66 v2(216.82,74.66)
  IN1 w0.102: v2(216.82,74.66) 216.82,74.76 217,74.94 217.46,74.94 217.61,74.79 217.61,72.99 216.8,72.17 212.28,72.17 207.76,76.69 207.4,76.69 207.07,76.36 206.87,76.36 206.61,76.62 206.61,76.77 207.03,77.18 207.03,77.5 206.62,77.9 206.31,77.9 205.89,77.49 205.75,77.49 198.33,84.91 198.33,86.41 v2(197.92,86.82)
  BOTTOM w0.127: v2(197.92,86.82) 197.52,87.22 U13.F19
VMA_RDQS1: length 37.9
  TOP w0.102: v2(193.79,85.22) 193.79,85.22 194.12,84.89 194.25,84.89 194.6,84.54 194.6,84.09 195.41,83.27 195.41,83.15 196.52,82.04 196.59,82.04
  TOP w0.127: 196.59,82.04 197.42,81.22 203.58,81.22 207.06,77.74 207.87,77.74 208.18,77.43 v1(208.9,77.43) 208.9,76.69 209.18,76.41 209.18,75.98 213.42,71.74 216.44,71.74 217.89,73.19 217.89,76.98 219.05,78.14 219.24,78.14 VRAM2.G3
  BOTTOM w0.127: v2(193.79,85.22) 193.79,85.17 193.42,84.8 U13.C14
VMA_RDQS2: length 32.7
  IN3 w0.127: v2(195.61,81.34) 195.79,81.52 195.92,81.52 197.81,79.63 202.71,79.63 210.83,71.51 216.89,71.51 217.89,72.51 217.89,73.21 218.32,73.65 218.32,74.41 218.6,74.69 218.78,74.69 v2(218.98,74.48)
  BOTTOM w0.127: U13.A16 195.16,83.08 195.16,81.49 195.31,81.34 v2(195.61,81.34) ; VRAM4.B7 219.05,74.42 v2(218.98,74.48)
VMA_RDQS3: length 34.4
  BOTTOM w0.127: U13.A22 200.12,83.32 200.39,83.32 200.62,83.09 200.62,82.35 201.68,81.29 202.67,81.29 203.41,80.55 203.97,80.55 204.19,80.34 204.19,79.78 204.55,79.41 204.94,79.41 205.41,79.88 205.61,79.88 205.86,79.63 205.86,79.43 205.39,78.96 205.39,78.57 205.81,78.16 206.2,78.16 206.66,78.62 206.87,78.62 207.11,78.38 207.11,78.17 206.65,77.71 206.65,77.32 207.12,76.85 207.58,76.85 207.99,77.25 208.26,77.25 208.43,77.08 v1(208.43,76.34) 209.17,76.34 210.41,75.1 210.87,75.1 211.25,75.47 213.19,75.47 213.42,75.24 213.42,73.65 214.51,72.55 217.08,72.55 217.61,73.09 217.61,77.31 216.7,78.22 216.51,78.22 VRAM4.G3
VMA_RDQS4: length 38.1
  TOP w0.102: v2(202.12,94.3) 202.29,94.48 202.29,94.66 202.64,95 203.24,95 203.52,94.73 204.72,94.73 205.27,95.27 205.27,95.34 205.29,95.36
  TOP w0.127: 205.29,95.36 206.1,96.18 206.1,99.35 206.38,99.62 206.94,99.62 207.07,99.75 207.07,100.13 206.94,100.26 206.38,100.26 206.1,100.53 206.1,101.16 206.4,101.46 206.91,101.46 207.07,101.62 207.07,109.03 207.58,109.54 208.42,109.54 208.94,110.06 208.94,110.79 209.28,111.12 209.77,111.12 210.02,111.37 v1(210.02,112.08) 210.72,112.08 211.38,112.74 216.21,112.74 218.47,110.48 218.47,109.03 218.68,108.83 219.27,108.83 VRAM1.B7
  BOTTOM w0.127: v2(202.12,94.3) 202.5,93.92 U13.P25
VMA_RDQS5: length 34.4
  TOP w0.14: v2(216.99,105.29) 216.54,105.29 VRAM1.G3
  IN1 w0.102: v2(216.99,105.29) 216.87,105.42 216.57,105.42 216.34,105.65 216.34,106.5 216.47,106.62 216.47,107.32 215.35,108.44 215.35,110.11 214.63,110.83 214.37,110.83 214.27,110.73 214.27,110.35 214.04,110.12 213.5,110.12 213.25,110.37 213.25,110.73 213.15,110.83 212.06,110.83 211.56,110.33 211.56,110.19 211.75,109.99 211.75,109.68 211.35,109.27 211.04,109.27 210.84,109.47 210.69,109.47 210.4,109.18 210.4,109.04 210.6,108.84 210.6,108.53 210.2,108.12 209.89,108.12 209.69,108.32 209.54,108.32 209.25,108.03 209.25,107.89 209.45,107.69 209.45,107.37 209.02,106.95 208.69,106.95 208.48,107.16 208.37,107.16 208.24,107.04 208.24,104.43 206.92,103.1 206.92,100.89 204.23,98.21 203.59,98.21 203.13,97.75 201.78,97.75 201.48,98.04 200.85,98.04 v2(200.48,98.42)
  BOTTOM w0.127: U13.W22 200.46,98.42 v2(200.48,98.42)
VMA_RDQS6: length 33.1
  BOTTOM w0.102: 216.82,108.77 216.8,108.75 216.5,108.75 216.37,108.62 216.18,108.62 216.06,108.49 215.86,108.49 215.73,108.62 215.73,108.8 216,109.07 VRAM3.B7
  BOTTOM w0.127: U13.AB27 204.29,100.31 204.42,100.31 204.53,100.42 204.53,100.54 204.61,100.62 205.52,100.62 207.32,102.42 207.32,104.27 209.66,106.61 209.66,111.92 210.6,112.86 212.26,112.86 212.39,112.74 212.39,111.84 212.68,111.54 213.12,111.54 213.53,111.96 213.53,112.74 213.66,112.86 214.04,112.86 214.17,112.74 214.17,112.28 214.44,112 215.04,112 215.31,112.28 215.31,112.74 215.44,112.86 216.83,112.86 216.98,112.71 216.98,112 217.15,111.82 217.15,110.98 217.18,110.96 217.18,110 217.15,109.97 217.15,109.89 217.74,109.31 217.74,108.93 217.58,108.77 216.82,108.77
VMA_RDQS7: length 31.2
  IN3 w0.127: v2(218.29,105.94) 217.87,106.36 217.87,106.72 217.64,106.96 217.64,107.26 217.34,107.56 216.07,107.56 215.71,107.91 215.45,107.91 215.1,107.56 214.32,107.56 213.96,107.91 213.34,107.91 212.96,107.53 212.96,106.63 212.43,106.1 211.59,106.1 211.31,106.39 210.72,106.39 210.57,106.24 210.57,105.68 210.31,105.42 209.58,105.42 209.41,105.24 209.41,104.99 209.93,104.47 209.93,104.06 209.62,103.75 208.97,103.75 208.85,103.62 208.85,101.85 207.75,100.75 207.75,100.15 207.23,99.63 206.9,99.63 206.73,99.8 206.55,99.8 206.41,99.66 206.41,95.49 206.13,95.21 205.76,95.21 205.37,95.6 205.37,96.3 205.16,96.51 204.34,96.51 204.25,96.41 204.25,96.29 v2(204.57,95.97)
  BOTTOM w0.127: U13.T27 204.14,95.54 v2(204.57,95.97)
  BOTTOM w0.14: v2(218.29,105.94) 218.37,105.86 218.92,105.86 219.17,105.61 219.17,105.42 VRAM3.G3
VMA_WDQS0: length 32.7
  TOP w0.127: v2(216.85,75.4) 216.5,75.4 VRAM2.C7
  IN1 w0.102: v2(216.85,75.4) 217.1,75.14 217.54,75.14 217.81,74.87 217.81,72.9 216.88,71.97 212.2,71.97 207.68,76.49 207.49,76.49 207.16,76.16 206.79,76.16 206.41,76.54 206.41,76.85 206.83,77.27 206.83,77.41 206.54,77.7 206.39,77.7 205.98,77.28 205.67,77.28 198.13,84.82 198.13,85.77 v2(197.92,85.98)
  BOTTOM w0.127: U13.E19 197.52,86.38 v2(197.92,85.98)
VMA_WDQS1: length 37.9
  TOP w0.102: 196.44,81.84 196.43,81.84 195.21,83.06 195.21,83.19 194.39,84 194.39,84.46 194.16,84.69 194.06,84.69 v2(193.81,84.44)
  TOP w0.127: 196.44,81.84 197.31,80.96 203.47,80.96 206.95,77.48 207.77,77.48 208,77.25 v1(208,76.53) 208.7,76.53 208.92,76.31 208.92,75.88 213.31,71.49 216.54,71.49 218.14,73.09 218.14,76.87 219.16,77.89 219.24,77.89 VRAM2.F3
  BOTTOM w0.127: v2(193.81,84.44) 193.81,84.39 194.22,84.8 U13.C15
VMA_WDQS2: length 32.7
  IN3 w0.127: v2(218.98,75.12) 218.78,74.92 218.51,74.92 218.09,74.5 218.09,73.74 217.66,73.31 217.66,72.6 216.8,71.74 210.92,71.74 202.81,79.86 197.91,79.86 196.01,81.75 195.84,81.75 v2(195.61,81.98)
  BOTTOM w0.127: v2(195.61,81.98) 195.41,82.18 195.41,83.63 U13.B16 ; v2(218.98,75.12) 219.08,75.21 VRAM4.C7
VMA_WDQS3: length 34.4
  BOTTOM w0.127: VRAM4.F3 216.19,77.74 216.19,77.89 216.26,77.96 216.59,77.96 217.36,77.2 217.36,73.19 216.97,72.81 214.62,72.81 213.67,73.75 213.67,75.35 213.29,75.73 211.14,75.73 210.77,75.35 210.52,75.35 209.3,76.57 v1(209.3,77.27) 208.6,77.27 208.36,77.51 207.88,77.51 207.48,77.1 207.23,77.1 206.91,77.42 206.91,77.6 207.37,78.06 207.37,78.48 206.98,78.87 206.56,78.87 206.1,78.41 205.92,78.41 205.65,78.68 205.65,78.86 206.11,79.32 206.11,79.74 205.72,80.13 205.3,80.13 204.84,79.67 204.66,79.67 204.44,79.89 204.44,80.44 204.07,80.81 203.52,80.81 202.78,81.55 201.79,81.55 200.87,82.46 200.87,83.2 200.49,83.58 199.98,83.58 199.88,83.68 199.88,83.88 U13.B22
