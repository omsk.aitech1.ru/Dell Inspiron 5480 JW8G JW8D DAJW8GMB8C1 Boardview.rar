# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INT_HDMI_TXN2: length 289.7
  TOP w0.114: C179.1 306.56,75.67 306.56,74.52 307.27,73.81 307.27,72.58 307.32,72.53 v2(307.48,72.38)
  IN3 w0.102: v2(176.77,51.19) 176.77,51.29 177.07,51.6 178.78,51.6 179.62,52.44 191.59,52.44 193.12,50.9 193.12,50.23 194.47,48.88 194.47,48.27 200.43,42.31 206.99,42.31 207.34,41.96 220.75,41.96 220.75,41.96 221.31,41.96 221.82,42.47 229.57,42.47 229.76,42.65 232.01,42.65 232.73,43.37 235,43.37 235.31,43.06 249.75,43.06 252.01,45.33 254.35,45.33 255.31,46.29 263.53,46.29 263.66,46.42 278.58,46.42 279.87,47.71 281.8,47.71 282.77,48.68 285.02,48.68 286.9,50.56 289.03,50.56 290.89,52.41 291.28,52.41 292.55,53.68 294.83,53.68 301.77,60.62 302.88,60.62 306.36,64.1 306.36,65.65 308.67,67.96 308.67,68.52 309.33,69.18 309.33,70.89 308.45,71.77 307.42,71.77 307.22,71.97 307.22,72.12 v2(307.48,72.38)
  BOTTOM w0.076: U14.C54 127.31,100.29 127.59,100.57 127.59,101.87 128.3,102.58 128.3,102.82 128.35,102.87 128.35,102.89
  BOTTOM w0.114: v2(176.77,51.19) 176.56,51.4 146.38,51.4 137.95,59.83 134.42,63.36 125.76,63.36 121.47,67.65 120.25,67.65 115.78,72.12 113.67,72.12 110.93,74.87 110.3,74.87 107.42,77.74 107.42,87.52 107.96,88.05 107.96,92.52 109.61,94.17 109.61,99.49 112.9,102.78 117.25,102.78 120.48,106.01 126.63,106.01 128.35,104.28 128.35,102.89
INT_HDMI_TXN2_C: length 5.2
  TOP w0.114: U2.2 308.72,79.6 308.64,79.52 308.64,79.3 308.09,78.75 307.4,78.75 307.32,78.68 v1(307.32,77.91) 306.64,77.91 306.56,77.83 306.56,77.21 C179.2
INT_HDMI_TXN2_L: length 10.8
  TOP w0.114: EL1.3 311.67,95.6 311.84,95.77 312.02,95.77 312.1,95.85 312.29,95.85 R44.2 312.79,95.87 314,95.87 v1(314.54,95.34) 315.07,95.87 316.36,95.87 317.66,94.58 318.7,94.58 319.12,94.16 319.12,94.16 319.67,93.61 319.83,93.61 CN3.3
INT_HDMI_TXN2_R: length 16.5
  TOP w0.114: U2.29 308.72,85.64 308.64,85.71 308.64,86.02 307.43,87.24 306.71,87.24 305.39,88.56 305.39,93.71 307.53,95.85 307.86,95.85 v1(308.47,95.24) 309.12,95.89 309.28,95.89 309.58,95.6 EL1.4
INT_HDMI_TXP0: length 291
  TOP w0.114: v2(310.24,73.75) 310.24,73.62 310.37,73.49 310.9,73.49 311.03,73.62 311.03,74.92 310.78,75.17 310.78,76.21 310.68,76.31 310.51,76.31 C182.1
  IN3 w0.102: v2(310.24,73.75) 310.68,73.75 310.8,73.62 310.8,72.38 310.62,72.2 309.97,72.2 308.45,73.72 306.63,73.72 305.77,72.87 305.77,71.77 306.76,70.78 308.15,70.78 308.44,70.49 308.44,69.97 304.96,66.49 304.96,64 303.36,62.39 299.96,62.39 291.4,53.83 291.05,53.83 288.66,51.45 286.53,51.45 284.68,49.59 282.41,49.59 281.44,48.63 279.52,48.63 278.2,47.31 263.29,47.31 263.16,47.18 254.94,47.18 253.98,46.21 251.54,46.21 249.28,43.95 236.23,43.95 235.77,44.41 232.09,44.41 231.22,43.54 229.39,43.54 229.21,43.36 221.45,43.36 220.95,42.85 207.71,42.85 207.36,43.2 200.82,43.2 195.41,48.61 195.41,49.24 194.52,50.13 194.52,50.87 191.99,53.4 176.92,53.4 v2(176.74,53.58)
  BOTTOM w0.076: U14.A55 126.75,101.57 126.83,101.49 126.9,101.49 127.03,101.62 127.03,102.21 127.39,102.56 127.39,102.76 127.34,102.81 127.34,102.83
  BOTTOM w0.114: 127.34,102.83 127.34,103.74 126.09,104.99 120.92,104.99 117.69,101.76 113.3,101.76 110.7,99.16 110.7,93.71 109.36,92.37 109.36,87.26 108.95,86.85 108.95,78.37 113.72,73.6 115.6,73.6 v1(116.11,74.1) 116.62,73.6 117.11,73.6 118.83,71.87 118.83,70.62 120.56,68.9 121.78,68.9 126.27,64.4 135.11,64.4 146.75,52.77 175.12,52.77 175.67,53.33 176.49,53.33 v2(176.74,53.58)
INT_HDMI_TXP0_C: length 4.1
  TOP w0.114: U2.6 310.32,79.6 310.39,79.52 310.39,79.03 310.62,78.8 310.62,78.42 v1(310.12,77.91) 310.62,77.41 310.62,77.21 C182.2
INT_HDMI_TXP0_L: length 15.4
  TOP w0.114: EL3.2 311.73,92.84 311.88,92.7 312.14,92.7 R55.1 312.77,92.85 313.65,92.85 314.31,92.19 314.67,92.19 314.97,92.49 v2(314.97,92.72)
  IN1 w0.102: v2(314.97,92.72) 315.49,92.2 316.01,92.2 316.47,92.66 316.47,93.59 317.61,94.73 319.13,94.73 319.49,94.37 319.49,91.09 319.75,90.82 319.86,90.82 CN3.7
INT_HDMI_TXP0_R: length 11.6
  TOP w0.114: EL3.1 308.41,92.84 307.98,92.42 307.98,91.93 307.55,91.5 307.55,90.99 v1(307.1,90.54) 307.5,90.14 307.5,89.44 308.13,88.82 308.86,88.82 310.32,87.36 U2.25
INT_HDMI_TXP1: length 290.3
  TOP w0.114: C180.1 308.36,75.77 308.36,75.47 v2(308.08,75.19)
  IN3 w0.102: v2(174.48,55.84) 174.48,56.15 175.17,56.83 191.52,56.83 197.82,50.52 197.82,48.31 197.82,48.14 201.6,44.37 207.84,44.37 208.19,44.02 220.08,44.02 220.95,44.88 229.38,44.88 230.08,45.58 238.47,45.58 238.95,46.06 247.59,46.06 248.79,47.27 250.53,47.27 251.6,48.34 262.68,48.34 262.83,48.5 277.74,48.5 279.06,49.82 280.92,49.82 281.88,50.79 284.22,50.79 286.05,52.61 288.18,52.61 290.72,55.15 290.95,55.15 300.82,65.03 300.82,66.18 303.72,69.07 303.72,73.18 305.9,75.37 305.9,78.37 306.03,78.5 307.99,78.5 308.39,78.9 308.39,80.7 308.5,80.81 309.17,80.81 309.33,80.65 309.33,77.81 309.15,77.63 306.93,77.63 306.69,77.39 306.69,76.43 306.93,76.19 308.26,76.19 308.44,76.01 308.44,75.54 v2(308.08,75.19)
  BOTTOM w0.076: 125.99,102.81 125.99,102.79 125.94,102.74 125.94,102.32 125.71,102.09 125.24,102.09 125.08,101.93 125.08,101.39 124.96,101.27 124.96,101.01 125.09,100.88 125.09,100.56 124.81,100.29 U14.C58
  BOTTOM w0.114: v2(174.48,55.84) 174.26,55.84 172.48,54.06 147.84,54.06 136.1,65.8 126.75,65.8 116.49,76.06 113.02,76.06 110.68,78.4 110.68,82.36 111.49,83.17 111.49,83.93 v1(111.01,84.42) 111.01,84.44 111.53,84.96 111.53,85.47 110.93,86.07 110.93,90.92 111.16,91.15 111.16,92.41 111.95,93.2 111.95,98.62 113.82,100.49 118.22,100.49 121.2,103.48 125.68,103.48 125.99,103.16 125.99,102.81
INT_HDMI_TXP1_C: length 4
  TOP w0.114: U2.4 309.52,79.64 309.58,79.57 309.58,78.65 308.47,77.54 308.47,77.21 C180.2
INT_HDMI_TXP1_L: length 10.8
  TOP w0.114: EL2.2 311.73,94.5 311.88,94.35 313.28,94.35 R52.1 313.81,94.35 316.14,94.35 316.44,94.04 316.44,93.64 315.78,92.98 315.78,92.78 316.23,92.33 316.81,92.33 v1(317.28,92.8) 317.75,92.33 318.31,92.33 CN3.4
INT_HDMI_TXP1_R: length 17
  TOP w0.114: U2.27 309.52,86.92 308.69,87.74 308.14,87.74 307.15,88.73 306.98,88.73 306.72,88.47 306.19,88.47 305.93,88.73 305.93,89.36 306.14,89.58 306.14,89.74 305.9,89.98 305.9,90.61 306.38,91.1 306.38,91.5 v1(305.98,91.91) 306.41,92.34 306.41,93.76 307.14,94.5 307.66,94.5 307.92,94.23 307.92,93.88 308.04,93.76 308.49,93.76 308.61,93.88 308.61,94.23 308.87,94.5 EL2.1
INT_HDMI_TXP2: length 289.7
  TOP w0.114: C178.1 306.1,76.05 306.31,75.85 306.31,74.41 307.02,73.7 307.02,72.4 306.89,72.27 306.66,72.27 v2(306.56,72.38)
  IN3 w0.102: v2(306.56,72.38) 306.56,72.5 306.69,72.63 306.89,72.63 307.02,72.5 307.02,71.89 307.34,71.56 308.36,71.56 309.13,70.8 309.13,69.26 308.47,68.6 308.47,68.04 306.15,65.73 306.15,64.18 302.79,60.82 301.68,60.82 294.75,53.88 292.46,53.88 291.19,52.61 290.8,52.61 288.95,50.76 286.82,50.76 284.94,48.88 282.68,48.88 281.72,47.92 279.79,47.92 278.49,46.62 263.58,46.62 263.44,46.49 255.22,46.49 254.26,45.53 251.93,45.53 249.67,43.27 235.39,43.27 235.09,43.57 232.65,43.57 231.93,42.85 229.67,42.85 229.49,42.67 221.74,42.67 221.23,42.16 220.83,42.16 207.42,42.16 207.07,42.51 200.52,42.51 194.67,48.36 194.67,48.97 193.33,50.31 193.33,50.99 191.68,52.64 179.54,52.64 178.7,51.8 176.82,51.8 v2(176.74,51.88)
  BOTTOM w0.076: U14.C55 126.75,100.27 126.85,100.17 126.96,100.17 127.11,100.32 127.11,100.54 127.01,100.65 127.01,100.87 127.44,101.31 127.44,101.93 128.15,102.64 128.15,102.82 128.1,102.87 128.1,102.89
  BOTTOM w0.114: 128.1,102.89 128.1,104.18 126.53,105.75 120.59,105.75 117.36,102.53 113.01,102.53 109.86,99.38 109.86,94.06 108.21,92.41 108.21,87.95 107.68,87.41 107.68,77.84 110.4,75.12 111.04,75.12 113.78,72.38 115.89,72.38 120.36,67.91 121.58,67.91 125.87,63.61 134.53,63.61 146.49,51.65 176.51,51.65 v2(176.74,51.88)
INT_HDMI_TXP2_C: length 5.2
  TOP w0.114: C178.2 306.31,77.21 306.31,77.94 306.42,78.06 v1(306.42,78.81) 307.1,78.81 307.29,79.01 307.99,79.01 308.39,79.41 308.39,79.52 308.32,79.6 U2.1
INT_HDMI_TXP2_L: length 10.8
  TOP w0.114: EL1.2 311.67,96.15 311.79,96.02 311.92,96.02 311.99,96.1 312.24,96.1 R44.1 312.79,96.13 314.05,96.13 v1(314.54,96.61) 315.02,96.13 316.47,96.13 317.76,94.83 318.81,94.83 319.77,93.86 319.97,93.86 320.24,94.13 CN3.1
INT_HDMI_TXP2_R: length 16.6
  TOP w0.114: EL1.1 308.83,96.15 v1(308.47,96.51) 308.06,96.1 307.42,96.1 305.14,93.81 305.14,88.45 306.61,86.98 307.33,86.98 308.39,85.92 308.39,85.71 308.32,85.64 U2.30
IRQ_SERIRQ: length 138.1
  TOP w0.102: R38.1 173.54,98.54 v2(173.39,98.69)
  IN3 w0.114: v2(182.94,50.53) 182.16,49.76 176.2,49.76 171.8,54.15 171.8,57.33 173.19,58.72 173.19,62.04 172.19,63.03 172.19,69.09 174.61,71.5 177.36,71.5 178.35,72.5 178.35,79.53 177.71,80.17 177.71,83.22 177.59,83.34 177.59,87.26 178.39,88.06 178.39,91.73 178.23,91.89 178.23,94.54 175.42,97.35 175.34,97.35 174,98.69 v2(173.39,98.69) 171.68,100.4 168.4,100.4 167.96,99.97 167.96,99.17 167.49,98.69 166.5,98.69 164.47,96.66 164.47,95.94 162.81,94.28 160.48,94.28 159.27,93.07 158.97,93.07 158.54,92.64 v2(158.49,92.64)
  BOTTOM w0.076: U14.T4 158.19,92.94 v2(158.49,92.64)
  BOTTOM w0.102: v2(182.94,50.53) 184.31,49.16 184.31,47.37 187.26,44.42 187.26,41.77 187.92,41.11 187.92,37.63 187.94,37.61 187.94,37.6 190.93,34.61 193.13,34.61 193.58,35.06 194.53,35.06 195.57,36.1 206.83,36.1 210.87,32.07 212.52,32.07 212.65,32.19 214.64,32.19 215.14,32.7 215.99,32.7 216.77,33.49 218.95,33.49 218.95,33.49 U23.5
ISET: length 9.1
  TOP w0.102: v2(306.48,83.37) 306.6,83.26 U2.34
  BOTTOM w0.102: v2(306.48,83.37) 305.98,82.87 305.98,81.93 v1(305.62,81.57) 305.62,80.45 306.33,79.74 306.87,79.74 v1(307.22,79.39) R383.1 R380.2
JTAG_TCK: length 10.4
  BOTTOM w0.102: TP18.1 179.51,100.11 179.94,100.54 179.94,102.2 180.68,102.93 181.8,102.93 182.13,102.6 183.66,102.6 183.92,102.87 183.92,103.13 184.22,103.43 185.52,103.43 U13.AE5
JTAG_TDI: length 11.1
  BOTTOM w0.102: U13.AE6 186.46,103.34 186.46,103.83 185.35,104.94 181.67,104.94 181.67,104.94 178.54,104.94 178.34,105.14 177.4,105.14 TP16.1
JTAG_TDO: length 9.4
  BOTTOM w0.102: TP15.1 178.93,105.14 179.87,105.14 180.01,105.28 185.47,105.28 186.8,103.96 U13.AF6
JTAG_TMS: length 13
  BOTTOM w0.102: TP19.1 179.48,97.65 180.32,98.49 180.32,101.46 181.24,102.37 181.85,102.37 182.41,101.81 183.71,101.81 183.89,101.99 183.89,102.47 184.02,102.6 186.4,102.6 U13.AD6
JTAG_TRST#: length 10.8
  BOTTOM w0.102: v1(178.72,102.78) 178.63,102.87 178.63,104.29 178.49,104.43 178.12,104.43 R295.1 178.02,104.74 179.3,104.74 180.58,103.46 183.64,103.46 183.88,103.7 183.88,103.97 184.08,104.18 184.49,104.18 184.64,104.33 184.83,104.33
  BOTTOM w0.381: 184.83,104.33 U13.AG4
KB_DET#: length 8.1
  BOTTOM w0.076: 163.43,92.52 163.41,92.54 163,92.54 162.54,92.09 162.54,91.81 162.05,91.31 160.86,91.31 160.32,90.77 U14.Y1
  BOTTOM w0.102: 163.43,92.52 163.79,92.52 163.86,92.44 166.4,92.44 166.63,92.21 166.63,91.79 R322.1
L_SPK+: length 9.5
  IN1 w1.016: 299.96,36.28 298.99,35.32 296.65,35.32 296.22,34.89 294.57,34.89 293.3,33.62 293.05,33.62 292.08,32.65 292.08,32.52
  vias: v1(308.36,40.02) v2(291.14,31.58) v2(291.78,31.58) v2(307.68,40.04) v2(307.68,39.41)
L_SPK+_R: length 4.9
  TOP w0.102: v2(294.8,32.55) 294.37,32.12 v1(294.37,31.91)
  BOTTOM w0.787: CN10.3 303.14,34.83
  BOTTOM w1.016: 303.14,34.83 303.13,34.83
  vias: v2(295.44,32.6) v2(300.95,34.68) v2(301.58,34.78)
L_SPK-: length 13.7
  IN1 w1.016: 292.24,35.52 293.02,35.52 293.91,36.41 295.59,36.41 296.99,37.81 298.79,37.81 299.58,38.59 303.43,38.59 303.82,38.21 304.53,38.21
  vias: v1(291.47,33.41) v2(291.37,34.17) v2(292.01,34.17) v2(306.99,40.19) v2(307.02,39.53)
L_SPK-_R: length 5.1
  TOP w0.114: v1(293.48,34) 293.56,33.92 v2(294.83,33.92)
  BOTTOM w0.787: 303.72,36.08 304.4,36.08 304.71,36.38 305.49,36.38 305.8,36.08 CN10.4
  vias: v2(295.61,33.97) v2(301.2,36.28) v2(301.74,35.95)
LAN_CLKREQ#: length 28.3
  TOP w0.102: v2(287.71,53.53) 287.99,53.25 288.88,53.25 v1(289.33,52.81) 289.77,52.36 289.77,50.81 290,50.59 U6.12
  BOTTOM w0.102: R445.1 282.83,39.6 Q42.3 ; R445.1 280.63,40.39 280.63,41.62 281.06,42.05 281.06,44 280.55,44.51 280.55,45.22 279.46,46.32 279.46,47.9 282.73,51.17 283.96,51.17 285.22,52.44 286.62,52.44 v2(287.71,53.53) ; R445.1 R446.2
LAN_ISOLAT#: length 6.6
  TOP w0.102: U6.20 287.1,48.06 287,47.97 286.64,47.97 286.54,48.07 285.71,48.07 285.61,47.97 v2(285.5,47.97)
  BOTTOM w0.102: v1(287.18,47.94) 288.21,47.94 R435.1 ; v1(287.18,47.94) 287.06,48.06 285.7,48.06 285.61,47.97 v2(285.5,47.97) ; v1(287.18,47.94) 287.18,48.36 287.6,48.78 R436.1
LAN_LED0: length 1.8
  TOP w0.102: U6.27 289.2,44.98 v2(289.03,44.82)
  BOTTOM w0.102: v2(289.03,44.82) 288.76,44.54 TP37.1
LAN_LED1: length 2.5
  TOP w0.102: U6.26 288.8,45.21 288.4,44.82 v2(288.27,44.82)
  BOTTOM w0.102: TP36.1 288.27,46.01 v2(288.27,44.82)
LAN_LED2: length 2.9
  TOP w0.102: U6.25 288.4,45.35 288.27,45.22 288.04,45.22 287.08,44.26 TP13.1
LAN_MCTG:
  vias: v1(313.55,58.53) v2(309.74,60.95) v2(310.37,60.95)
LAN_MCTG0: length 2.4
  TOP w0.508: R145.1 v2(311.13,55.99)
  BOTTOM w0.508: 310.9,56.03 310.94,55.99 v2(311.13,55.99)
  BOTTOM w0.762: 310.9,56.03 U19.15
  vias: v1(311.64,57.16)
LAN_MCTG1: length 2.4
  TOP w0.508: R147.1 312.11,54.76 v2(311.1,54.76)
  BOTTOM w0.762: U19.16 v2(311.1,54.76)
  vias: v1(311.46,53.76)
LAN_MCTG2: length 3.3
  TOP w0.102: v2(311.1,48.41) 311.03,48.47 311.03,49.26 v1(311.1,49.33)
  TOP w0.508: R156.1 312.11,48.41 v2(311.1,48.41)
  BOTTOM w0.508: U19.21 v2(311.1,48.41)
LAN_MCTG3: length 3.3
  TOP w0.102: v1(312.14,46.12) R159.1
  TOP w0.508: R159.1 v2(311.13,47.1)
  BOTTOM w0.508: U19.22 309.83,47.1 v2(311.13,47.1)
LAN_MX0+: length 9.2
  BOTTOM w0.089: U19.24 310.53,44.6 311.02,45.08 311.88,45.08 v1(312.38,44.59) 312.88,45.08 316.26,45.08 317.38,46.21 CN7.1
LAN_MX0-: length 9.2
  BOTTOM w0.089: CN7.2 317,47.08 317,46.24 316.14,45.38 312.86,45.38 v1(312.38,45.86) 311.9,45.38 311.02,45.38 310.53,45.87 U19.23
LAN_MX1+: length 9.7
  TOP w0.089: CN7.3 317.82,48.37 316.37,48.37 315.51,49.22 315.29,49.22 314.88,49.64 314.88,49.83 314.68,50.02 314.56,50.02 v2(314.43,49.9)
  BOTTOM w0.089: U19.20 310.5,49.68 310.94,50.11 311.7,50.11 v1(312.2,49.62) 312.7,50.11 314.22,50.11 v2(314.43,49.9)
LAN_MX1-: length 9.7
  TOP w0.089: v2(314.43,50.57) 314.69,50.32 314.8,50.32 315.17,49.95 315.17,49.76 315.41,49.52 315.65,49.52 316.39,50.25 316.39,50.58 316.29,50.68 316.29,51.17 316.43,51.31 CN7.6
  BOTTOM w0.089: v2(314.43,50.57) 314.27,50.41 312.68,50.41 v1(312.2,50.89) 311.71,50.41 311.03,50.41 310.49,50.95 U19.19
LAN_MX2+: length 9.9
  BOTTOM w0.089: CN7.4 317.03,49.44 317.03,50.05 316.89,50.19 315.86,50.19 313.42,52.64 313.3,52.75 312.44,52.75 v1(311.95,52.26) 311.45,52.75 310.97,52.75 310.7,52.49 310.7,52.39 310.53,52.22 U19.18
LAN_MX2-: length 9.9
  BOTTOM w0.089: U19.17 310.53,53.49 310.97,53.05 311.46,53.05 v1(311.95,53.53) 312.43,53.05 313.42,53.05 314.47,52 315.98,50.48 317.01,50.48 317.2,50.29 CN7.5
LAN_MX3+: length 11.6
  BOTTOM w0.089: CN7.7 317.2,52.33 317.1,52.22 316.23,52.22 315.34,53.11 315.34,54 313.56,55.78 v1(312.87,55.78) 312.87,56.46 311.59,57.75 310.98,57.75 310.53,57.3 U19.14
LAN_MX3-: length 11.6
  BOTTOM w0.089: CN7.8 317.08,53.12 317.08,52.61 316.97,52.51 316.35,52.51 315.63,53.23 315.63,54.12 313.77,55.97 v1(313.77,56.68) 313.07,56.68 311.71,58.04 311.06,58.04 310.53,58.57 U19.13
LAN_PWR_EN_EC: length 62.5
  TOP w0.102: v2(281.62,35.7) 280.68,36.64 279.74,36.64 v1(279.54,36.84) 279.4,36.98 278.84,36.98 278.44,37.37 278.44,39.31 278.62,39.48 PR61.1
  IN1 w0.089: v2(281.62,35.7) 281.75,35.57 281.75,31.41 280.07,29.73 269.81,29.73 267.83,31.71 266.44,31.71 264.3,33.84 261.45,33.84 260.95,33.34 256.9,33.34 256.49,33.75 253.38,33.75 252.51,32.88 249.92,32.88 249.37,33.43 244.68,33.43 244,32.75 239.5,32.75 v2(239.25,32.5)
  BOTTOM w0.102: v2(239.25,32.5) 238.49,33.26 237.55,33.26 237.27,33.54 237.27,34.61 236.39,35.49 U23.87
LAN_PWR_EN_EC_R: length 5.1
  TOP w0.102: v1(277.76,39.84) 277.88,39.97 279.41,39.97 279.65,39.73 ; 279.65,39.73 PC39.1 279.76,40.5 280.78,39.49 PU2.3 ; 279.65,39.73 PR61.2
LAN_RST#: length 6.6
  TOP w0.102: U6.19 v2(286.71,48.46)
  BOTTOM w0.102: v1(288.73,51.5) 288.59,51.5 R431.2 ; v2(286.71,48.46) 287.17,48.92 287.17,50.07 R431.2 ; R433.2 286.62,50.16 286.99,50.53 R431.2
LAN_XTALI: length 6.4
  TOP w0.127: Y4.3 289.31,41.43 289.31,42.97 v1(289.09,43.19) 289.04,43.23 C239.1 289.6,44.74 U6.28
LAN_XTALO: length 4.3
  TOP w0.127: U6.29 290,45.22 289.9,45.12 289.9,44.71 C240.1 v1(290.42,43.19) 290.42,43.03 290.09,42.69 290.09,42.16 Y4.1
LATCH: length 62.3
  TOP w0.102: D4.1 210.7,38.64 208.62,40.73 207.81,40.73 v2(206.66,41.87) ; D7.1 Q33.3 189.97,21.45 189.46,21.97 C397.1 187.94,22.47 187.31,21.83 Q32.5 187.31,20.05 187.18,19.93 186.8,19.93 186.66,20.07 Q32.6 186.66,21.57 186.48,21.75 185.58,21.75 185.4,21.57 R280.1 184.61,21.2 v1(184.16,21.65) 184.16,22.52 184.39,22.74 187.28,22.74 187.66,23.13 187.66,27.95 v2(188.02,28.31)
  IN2 w0.114: v2(188.02,28.31) 191.27,28.31 195.46,32.5 206.03,32.5 206.71,33.18 206.71,35.01 208.85,37.15 208.85,40.6 207.58,41.87 v2(206.66,41.87)
LCD_BAK: length 101
  TOP w0.102: v2(224.37,40.63) 224.98,41.24 233.74,41.24 234.96,40.02 237.75,40.02 238.54,39.23 v1(238.54,38.49) v2(238.54,32.5)
  IN1 w0.089: v2(265.29,32.29) 265.26,32.32 264.96,32.32 264.47,32.8 261.38,32.8 261.03,33.15 256.82,33.15 256.46,33.51 253.65,33.51 251.32,31.18 249.97,31.18 249.25,31.9 245.28,31.9 244.76,32.42 240.19,32.42 239.76,31.99 239.05,31.99 v2(238.54,32.5)
  BOTTOM w0.102: v2(265.29,32.29) 265.29,32.4 265.96,33.07 265.96,35.57 266.39,36 267.04,36 267.93,36.89 270.65,36.89 271.41,36.13 274.56,36.13 274.68,36.26 274.68,39.94 273.64,40.98 271.74,40.98 271.36,41.36 271.36,42.66 271.84,43.14 273.39,43.14 273.7,43.45 275.12,43.45 275.79,42.77 275.79,40.53 R525.1 276.68,39.64 279.28,39.64 D22.2 280.58,38.87 280.77,38.68 280.77,37.62 280.48,37.32 v1(280.48,37.1) 280.48,37.07 280.75,36.79 280.75,36.59 281.24,36.1 282.79,36.1 283.32,35.57 283.32,34.44 282.85,33.97 282.85,33.25 283,33.1 CN11.24 ; v2(224.37,40.63) 224.37,42.01 222.29,44.09 U23.35
LCD_BAK_IN: length 3.8
  BOTTOM w0.102: R525.2 276.56,40.9 R502.2 278.1,40.11 278.85,40.85 D22.3
LCD_BL_PWM: length 13.1
  BOTTOM w0.114: U13.D6 186.79,85.6 186.73,85.54 186.36,85.18 185.73,85.18 185.5,84.95 185.5,84.64 185.25,84.39 184.13,84.39 183.88,84.14 183.88,83.76 183.68,83.55 183.32,83.55 183.01,83.24 182.52,83.24 181.55,82.28 178.18,82.28 177.24,81.34 TP33.1
LCD_BLEN: length 6.8
  TOP w0.102: v2(189.7,86.83) 190.05,86.83 190.64,86.24 190.64,84.79 190.58,84.73 190.58,82.58 TP11.1
  BOTTOM w0.114: U13.F9 189.69,86.83 v2(189.7,86.83)
LCD_DBC: length 210.4
  TOP w0.102: v2(172.19,90.44) 171.71,90.44 171.03,89.75 168.36,89.75 167.98,90.13 166.89,90.13 166.58,89.83 v1(166.21,89.83) 165.81,89.83 165.43,89.44 164.5,89.44 162.87,91.07 160.21,91.07 159.67,90.53 158.33,90.53 158.3,90.57 157.45,90.57 v2(157.03,90.15)
  IN3 w0.114: v2(265.46,31.69) 264.96,31.18 263.71,31.18 260,27.47 257.77,27.47 257.28,27.95 253.25,27.95 252.81,27.52 246.64,27.52 244.38,29.78 237.51,29.78 236.58,30.71 236.58,31.29 236.27,31.59 232.09,31.59 231.46,32.22 229.92,32.22 229.83,32.3 227.09,32.3 227.02,32.23 226.94,32.23 226.6,31.89 226.6,31.56 226.09,31.05 221.9,31.05 221.9,31.05 221.6,31.05 219.33,31.05 218.31,30.03 213.83,30.03 213.03,30.83 210.18,30.83 208.62,32.4 207.4,32.4 206.71,31.71 200.46,31.71 199.72,32.45 197.46,32.45 195.32,34.59 190.5,34.59 182.48,42.61 179.68,42.61 178.11,44.18 175.93,44.18 174.49,45.62 173.88,45.62 164.84,54.66 164.84,64.49 167.8,67.45 167.8,70.52 173.46,76.19 173.46,81.41 173.82,81.77 173.82,84.9 173.2,85.51 173.2,87.32 171.92,88.61 171.92,89.47 172.19,89.75 v2(172.19,90.44)
  BOTTOM w0.102: v2(265.46,31.69) 266.25,32.47 266.25,35.52 266.51,35.77 267.14,35.77 267.93,36.56 270.44,36.56 271.1,35.9 274.76,35.9 274.91,36.05 274.91,40.07 273.79,41.18 272.07,41.18 271.79,41.46 271.79,42.71 272.01,42.94 273.48,42.94 273.78,43.24 275.03,43.24 275.51,42.76 275.51,39.73 275.85,39.39 276.85,39.39 277.35,38.89 R480.2 ; U14.AB6 156.86,89.98 157.03,90.15 v2(157.03,90.15) ; R337.1 170.54,88.73 170.56,88.76 171.46,88.76 171.79,89.09 171.79,90.03 v2(172.19,90.44)
LCD_DBC_R: length 9.2
  BOTTOM w0.102: CN11.22 282,33.08 281.03,34.05 279.82,34.05 279.21,34.67 279.21,35.88 277.35,37.73 R480.1 277.22,37.95 276.82,37.55 v1(276.31,37.55)
LCD_PWM: length 228.4
  TOP w0.102: D17.1 274.2,26.68 v2(273.79,26.28) ; v2(190.88,48.31) 190.73,48.45 190.38,48.45 189.75,47.81 189.75,45.45 189.34,45.05 186.5,45.05 185.78,44.33 185.78,40.09 v1(186.22,39.66) 186.98,38.9 186.98,33.49 v2(186.8,33.31)
  IN1 w0.089: v2(133.18,106.16) 133.18,106.34 134.34,107.5 138.59,107.5 140.34,109.26 143.8,109.26 144.33,108.72 149.56,108.72 152.06,111.23 156.12,111.23 159.9,107.45 160.38,107.45 161.12,106.71 v2(161.91,106.71)
  IN2 w0.114: v2(161.91,106.71) 162.16,106.46 162.16,105.54 163.71,103.99 169.73,103.99 169.73,103.99 170.04,103.99 170.04,103.99 170.29,103.99 177.78,96.5 177.78,93.01 177.81,92.98 179.14,91.65 179.14,88.76 177.09,86.71 177.09,78.22 178.05,77.25 178.05,75.65 178.45,75.25 178.45,73.4 179.88,71.98 179.88,69.11 180.34,68.65 180.34,67.25 181.63,65.97 181.63,59.92 187.16,54.39 187.16,49.58 188.99,47.76 190.31,47.76 190.86,48.31 v2(190.88,48.31)
  IN3 w0.114: v2(273.79,26.28) 270.92,29.15 264.83,29.15 264.32,29.65 262.8,29.65 260.18,27.04 244.23,27.04 243.72,26.53 242.43,26.53 241.74,27.21 241.74,27.75 241.41,28.08 240.75,28.08 240.47,27.8 236.68,27.8 236.63,27.85 236.6,27.85 236.26,28.19 236.08,28.38 234.17,28.38 234.12,28.43 232.61,29.94 230.45,29.94 230.45,29.94 230.18,29.94 229.69,29.45 229.08,29.45 227.49,29.45 226.3,28.26 220.38,28.26 220.21,28.09 211.05,28.09 211.04,28.1 210.98,28.1 210.14,28.94 209.42,28.94 208.63,29.73 199.64,29.73 199.53,29.83 198.8,30.57 197.48,30.57 193.3,30.57 191.27,32.6 187.51,32.6 v2(186.8,33.31)
  BOTTOM w0.076: v2(133.18,106.16) 133.42,105.92 R291.2
  BOTTOM w0.102: R293.1 v2(161.91,106.71)
LCD_PWM_EC: length 74.1
  TOP w0.102: D17.2 274.2,29.63 275.3,30.73 275.3,30.91 275.73,31.33 275.73,34.1 274,35.83 271.86,35.83 271.69,35.65 270.09,35.65 269.78,35.34 269.78,34.5 269.5,34.23 266.25,34.23 266.04,34.44 266.04,35.11 264.45,36.7 264.45,37.11 264.18,37.37 262.31,37.37 261.22,38.47 261.17,38.47 259.74,39.89 259.6,39.89 258.61,40.88 256.42,40.88 256.29,40.75 253.96,40.75 252.97,39.76 252.97,37.83 252.33,37.2 250.55,37.2 250.35,37.4 250.35,38.42 249.84,38.92 243.85,38.92 v1(241.84,40.93) 241.33,40.43 236.05,40.43 235.03,41.44 223.91,41.44 v2(223.2,40.73)
  BOTTOM w0.102: U23.29 221.68,43.09 223.2,41.57 v2(223.2,40.73)
LCD_PWM_IN: length 13.5
  TOP w0.102: D17.3 276.18,29.86 275.69,30.35 R454.1 275.93,30.83 275.93,31.84 276.59,32.5 279.35,32.5 279.7,32.85 v1(279.7,33.6) 279.89,33.79 v2(279.89,34.56)
  BOTTOM w0.102: v2(279.89,34.56) 280.93,34.56 282.5,32.99 CN11.23
LCD_TST: length 72.7
  TOP w0.102: v2(231.45,37.53) 231.45,37.22 230.72,36.49 224.93,36.49 224.52,36.08 224.52,35.44 v1(224.37,35.29) 223.38,34.3 R216.1
  IN3 w0.114: v2(275.62,37.43) 275.54,37.35 270.17,37.35 268.3,39.22 264.41,39.22 263.89,39.74 259.95,39.74 259.06,38.85 256.9,38.85 256.65,39.1 252.51,39.1 252.13,39.48 242.45,39.48 241.71,38.75 240.04,38.75 238.57,37.27 234.93,37.27 234.23,37.97 231.9,37.97 v2(231.45,37.53)
  BOTTOM w0.102: D18.2 274.99,42.68 275.26,42.42 275.26,37.79 v2(275.62,37.43) 276.32,36.73 277.8,36.73 278.93,35.6 278.93,34.66 279.74,33.84 280.68,33.84 281.5,33.02 CN11.21
LCD_TST_R: length 5.2
  TOP w0.102: v2(223.4,31.69) 223.4,32.84 R216.2 223.67,32.87 223.78,32.98 223.78,33.64 224.06,33.92 v1(224.37,33.92)
  BOTTOM w0.102: v2(223.4,31.69) 222.99,31.28 222.51,31.28 222.29,31.06 U23.126
LCD_VCC: length 2.7
  TOP w0.102: TP10.1 187.97,84.24 v2(187.97,84.4)
  BOTTOM w0.114: v2(187.97,84.4) 187.97,84.4 187.97,84.43 U13.C7
LID_SW#: length 307.5
  TOP w0.102: HE1.1 19.72,107.73 19.77,107.68 20.65,107.68 21.31,108.34 C13.2 21.18,108.95 v2(20.63,108.95) ; v2(231.33,22.01) 231.02,22.31 231.02,23.24 231.33,23.56 233.53,23.56 233.99,24.02 233.99,26.55 234.58,27.14 v1(235.06,27.14) 236.28,28.36 236.28,30.59 236.28,30.6 236.28,30.88 237.9,32.5 v2(237.9,32.52) 237.9,32.57 236.97,33.51 R221.1
  IN1 w0.089: v2(231.33,22.01) 231.1,22.24 222.08,22.24 221.42,21.58 211.97,21.58 211.6,21.21 210.27,21.21 209.94,21.54 205.08,21.54 203.62,22.99 201.5,22.99 201.31,22.8 200.54,22.8 199.3,24.04 193.2,24.04 190.74,26.5 189.34,26.5 188.64,27.2 188.64,28.57 181.9,35.32 156.55,35.32 154.14,32.9 146.82,32.9 145.37,34.36 140.61,34.36 138.91,36.05 116.49,36.05 114.33,38.21 111.84,38.21 109.3,40.75 99.35,40.75 97.8,39.2 v2(83.8,39.2)
  IN3 w0.114: v2(83.8,39.2) 83.8,46.19 81.95,48.04 49.74,48.04 47.73,50.05 42.2,50.05 24.54,67.7 24.54,78.93 15.96,87.51 15.96,106.26 18.65,108.95 v2(20.63,108.95)
  BOTTOM w0.102: v2(237.9,32.52) 237.9,32.6 237.07,33.44 237.07,34.4 236.38,35.09 U23.88
LPC_CLK_0: length 12.4
  BOTTOM w0.076: U14.AN15 152,83.14 152.33,82.82 152.33,82.6 152.26,82.53 152.26,82.2 152.31,82.15 152.31,81.86 151.96,81.52 151.47,81.52 151.19,81.24 151.19,80.94 151.21,80.92 151.21,80.55 151.19,80.53 151.19,80.29 151.36,80.12 151.58,80.12 151.81,79.88 151.81,78.92 151.52,78.62 151.52,73.99 v1(151.25,73.73) 150.61,73.09 R410.1
LPC_CLK_1: length 13.4
  TOP w0.102: v2(151.55,83) 152.08,82.47 152.08,81.72 148.65,78.29 148.65,77.3 148.88,77.07 v1(148.88,74.84) 148.88,74.39 148.45,73.96 R116.1 R117.1
  BOTTOM w0.102: v2(151.55,83) 151.86,82.69 U14.AP15
LPC_CLK_DEBUG: length 117.8
  TOP w0.102: R116.2 148.45,69.63 156.35,61.73 156.35,57.31 155.18,56.15 136.69,56.15 129.95,62.88 122.1,62.88 121.39,63.58 v2(121.39,64.38) 120.81,64.96 v1(120.73,64.96) ; v2(80.78,38.59) 80.78,38.67 79.71,39.74 R233.1
  IN1 w0.089: v2(121.39,64.38) 121.01,63.99 121.01,61.71 120.59,61.28 120.59,59.45 116.63,55.49 116.63,54.3 116.63,53.14 107.72,44.23 104.96,44.23 103.45,42.72 100.4,42.72 97.48,39.8 82.24,39.8 81.03,38.59 v2(80.78,38.59)
LPC_CLK_EC: length 110.9
  TOP w0.102: v2(217.38,35.77) 217.03,35.43 EC5.1 217.03,34.55 R223.2 215.55,33.07 215.55,32.73 214.74,31.91 v2(214.74,31.36)
  BOTTOM w0.102: U23.13 217.68,36.69 217.38,36.38 v2(217.38,35.77) ; R410.2 149.83,72.33 149.36,71.86 149.36,62.29 154.57,57.09 164.76,57.09 169.15,61.48 175.93,61.48 182.28,55.13 182.28,50.33 183.7,48.91 183.7,47.12 186.04,44.78 186.04,41.45 186.7,40.79 186.7,37.3 190.48,33.52 193.58,33.52 194.03,33.97 195.03,33.97 196.05,34.99 206.4,34.99 209.84,31.55 209.84,31.21 210.2,30.85 214.23,30.85 v2(214.74,31.36)
LPC_LAD0: length 202.9
  TOP w0.102: v2(165.9,64.48) 164.14,62.72 164.14,58.13 158.56,52.54 119.85,52.54 116.34,49.03 116.34,44.84 117.23,43.95 117.23,41.64 116.65,41.06 115.81,41.06 115.76,41.01 115.3,40.54 115.25,40.5 115.12,40.37 115.12,39.78 114.62,39.28 112.72,39.28 110.31,41.69 106.56,41.69 105.87,41.01 99.23,41.01 v1(87.95,41.01) R489.2
  BOTTOM w0.076: U14.AU14 152.61,80.76 153.2,80.76 153.52,80.44 153.52,80.26 153.66,80.12 153.84,80.12 154.06,79.89 154.06,77.51 152.66,76.11 152.66,72.02 152.81,71.87 152.81,71.54
  BOTTOM w0.102: U23.10 218.69,35.49 218.19,34.99 216.21,34.99 215.96,35.24 214.28,35.24 214.08,35.44 213.29,35.44 212.99,35.14 211.21,35.14 207.83,38.52 199.45,38.52 199.12,38.85 199.12,42.89 196.96,45.05 190.05,45.05 186.72,48.37 186.72,50.21 184.92,52.01 184.92,56.22 177.27,63.87 171.5,63.87 170.71,64.65 166.07,64.65 v2(165.9,64.48) 164.85,63.44 156.65,63.44 152.81,67.27 152.81,67.3 152.81,67.99 152.81,67.99 152.81,71.54
LPC_LAD0_R: length 19.5
  TOP w0.102: v2(74.01,39.24) 74.14,39.37 74.77,39.37 75.7,38.44 78.77,38.44 80.42,36.79 82.36,36.79 84.29,38.72 84.29,40.63 v1(84.64,40.98) 84.67,41.01 R489.1
  BOTTOM w0.102: CN14.64 72.81,41.2 74.01,40 v2(74.01,39.24)
LPC_LAD1: length 201.9
  TOP w0.102: v2(166.35,63.95) 164.7,62.3 164.7,57.9 159.01,52.21 120.2,52.21 116.82,48.83 116.82,45.04 117.76,44.1 117.76,41.49 116.85,40.58 116.01,40.58 115.53,40.09 115.53,39.51 114.82,38.8 112.52,38.8 110.11,41.21 106.79,41.21 106.36,40.78 94.98,40.78 93.81,39.61 v1(89.49,39.61) 87.49,39.61 87.23,39.86 R488.2
  BOTTOM w0.076: 153.31,78.78 153.31,79.47 U14.AW12
  BOTTOM w0.102: 153.31,78.78 153.31,78.18 152.48,77.35 152.48,72.43 152.33,72.27 152.33,68.19 152.33,66.68 156.11,62.91 165.31,62.91 v2(166.35,63.95) 166.58,64.17 170.51,64.17 171.3,63.38 176.99,63.38 184.41,55.96 184.41,51.84 186.24,50.01 186.24,48.17 189.85,44.56 196.41,44.56 198.36,42.61 198.36,38.72 199.04,38.04 207.63,38.04 211.01,34.66 213.19,34.66 213.49,34.96 213.88,34.96 214.1,34.73 218.4,34.73 218.75,35.09 U23.9
LPC_LAD1_R: length 18.6
  TOP w0.102: R488.1 85.56,39.86 84.87,39.18 v1(84.87,39.05) 84.87,38.78 82.57,36.48 80.33,36.48 78.57,38.24 75.2,38.24 74.59,38.85 v2(74.53,38.85)
  BOTTOM w0.102: v2(74.53,38.85) 74.53,39.87 72.69,41.7 CN14.66
LPC_LAD2: length 201.2
  TOP w0.102: R487.2 v1(91.27,38.72) 93.25,38.72 95.08,40.55 106.82,40.55 106.99,40.73 109.91,40.73 112.32,38.31 115.02,38.31 115.76,39.05 115.91,39.05 118.27,41.41 118.27,49.6 120.55,51.88 159.36,51.88 165.23,57.75 165.23,61.88 v2(166.86,63.51)
  BOTTOM w0.102: U14.AY12 153.02,78.35 152.28,77.61 152.28,72.66 151.85,72.22 151.85,68.39 151.85,66.48 155.91,62.42 165.77,62.42 v2(166.86,63.51) 166.94,63.59 170.41,63.59 171.1,62.9 176.79,62.9 183.93,55.76 183.93,51.64 185.76,49.81 185.76,47.97 189.65,44.08 195.92,44.08 197.47,42.53 197.47,38.47 198.38,37.55 207.43,37.55 210.89,34.1 215.73,34.1 216.04,34.4 218.58,34.4 218.86,34.69 U23.8
LPC_LAD2_R: length 22.1
  TOP w0.102: R487.1 85.45,38.72 82.93,36.19 79.47,36.19 v1(79.34,36.32) 78.96,35.94 77.31,35.94 75.92,37.34 74.87,37.34 73.26,38.95 70.75,38.95 v2(70.47,39.23)
  BOTTOM w0.102: v2(70.47,39.23) 70.47,41.79 70.88,42.2 CN14.68
LPC_LAD3: length 207.6
  TOP w0.102: v2(167.29,63) 165.82,61.53 165.82,57.65 159.62,51.45 120.8,51.45 118.83,49.47 118.83,41.44 116.44,39.05 116.44,37.96 116.09,37.6 115.45,37.6 115.22,37.83 112.12,37.83 109.66,40.3 95.21,40.3 92.92,38.01 v1(88.3,38.01) 87.79,38.01 87.36,37.58 R486.2
  BOTTOM w0.076: 152.08,74.8 152.08,77.81 152.73,78.46 152.73,79.88 152.9,80.05 153.48,80.05 U14.AW11
  BOTTOM w0.102: U23.7 218.92,34.29 218.78,34.15 216.31,34.15 215.77,33.62 210.69,33.62 207.23,37.07 195.17,37.07 194.13,36.03 190.89,36.03 189.01,37.91 189.01,44.04 185.28,47.77 185.28,49.61 183.45,51.44 183.45,55.56 176.59,62.42 170.65,62.42 169.96,63.11 167.39,63.11 v2(167.29,63) 166.2,61.91 155.74,61.91 151.37,66.28 151.37,66.7 151.37,72.15 152.08,72.86 152.08,74.8
LPC_LAD3_R: length 23.1
  TOP w0.102: R486.1 85.23,37.58 v1(84.72,37.07) 83.33,35.69 77.28,35.69 75.83,37.13 74.77,37.13 73.26,38.64 70.42,38.64 v2(69.83,39.23)
  BOTTOM w0.102: v2(69.83,39.23) 69.83,41.67 70.87,42.7 CN14.70
LPC_LFRAME#: length 208.4
  TOP w0.102: R485.1 87.54,36.56 87.99,37.02 v1(90.1,37.02) 92.49,37.02 95.54,40.07 109.2,40.07 111.92,37.35 116.21,37.35 116.75,37.88 116.75,39 119.13,41.39 119.13,49.1 121.08,51.04 159.89,51.04 166.35,57.5 166.35,61.15 v2(167.75,62.55)
  BOTTOM w0.076: 150.86,71.49 150.99,71.62 150.99,72.12 151.9,73.04 151.9,78.12 152.56,78.78 152.56,79.99 U14.AV12
  BOTTOM w0.102: 150.86,71.49 150.86,66.11 155.54,61.43 166.63,61.43 v2(167.75,62.55) 169.76,62.55 170.21,62.09 176.23,62.09 182.89,55.43 182.89,55.38 182.89,54.88 182.89,54.88 182.89,51.32 184.79,49.41 184.79,47.57 187.82,44.55 187.82,41.9 188.4,41.31 188.4,37.83 190.69,35.55 194.33,35.55 195.37,36.59 207.03,36.59 210.51,33.11 215.86,33.11 216.64,33.89 U23.6
LPC_LFRAME#_R: length 23.5
  TOP w0.102: R485.2 85.95,35.79 85.59,35.43 79.35,35.43 78.37,34.45 77.58,34.45 v1(77.25,34.78) 76.57,34.78 v2(75.15,36.19)
  BOTTOM w0.102: v2(75.15,36.19) 75.03,36.32 75.03,37.81 75.38,38.16 75.66,38.16 75.88,38.38 75.88,39.08 76.6,39.8 76.6,43.14 76.98,43.51 78.16,43.51 78.22,43.45 CN14.73
LPT_CR_RST#: length 18.2
  TOP w0.102: R74.1 172.84,85.56 172.55,85.56 172.07,86.04 v1(171.86,86.04) 171.64,86.26 170.28,86.26 170.04,86.5 170.04,86.9 169.27,87.67 167.94,87.67 167.68,87.41 164.14,87.41 163.91,87.64 160.1,87.64 160.05,87.69 158.2,87.69 158.1,87.79 157.29,87.79 157.03,87.54 v2(157.03,87.3)
  BOTTOM w0.102: v2(157.03,87.3) 157.03,87.01 U14.AG6
LPT_DDR_PG_CTRL: length 29.7
  TOP w0.305: v2(117.33,59.8) v1(116.39,59.8) 115.93,59.8 R143.1
  IN1 w0.305: v2(122.16,78.27) 122.16,77.76 118.85,74.46 118.85,69.96 120.48,68.34 120.48,66.38 118.09,63.99 118.09,63.49 116.82,62.22 116.82,60.31 v2(117.33,59.8)
  BOTTOM w0.076: U14.AV61 123.44,80.69 123.46,80.7 123.7,80.7 123.87,80.53 123.87,80.29 123.63,80.05 123.46,80.05 123.25,79.85 123.25,79.51 123.06,79.33 123.06,78.41 122.92,78.27 v2(122.16,78.27)
LPT_LAN_RST#: length 18.1
  TOP w0.102: v2(157.68,87.3) 157.79,87.3 157.97,87.49 159.93,87.49 159.98,87.44 163.23,87.44 163.46,87.21 167.77,87.21 168.02,87.46 168.91,87.46 169.81,86.57 169.81,86 v1(170.27,85.53) 170.48,85.74 171.47,85.74 171.86,85.35 171.86,84.97 172.07,84.77 172.31,84.77 172.64,84.44 R77.1
  BOTTOM w0.102: U14.AG5 157.51,87.13 v2(157.68,87.3)
M_B_A0: length 54.9
  IN1 w0.076: v2(135.62,82.55) 135.23,82.15 135.23,81.73 134.35,80.85 134.35,77.74 134.19,77.57 134.19,76.31
  IN1 w0.14: 134.19,76.31 134.19,76.01 132.05,73.87 132.05,71.26 131.35,70.56 131.35,66 132.79,64.56 132.79,59.26 145.12,46.93 145.12,45.42 146.34,44.2 146.34,40.22 v2(146.19,40.07)
  BOTTOM w0.165: U14.AP40 135.95,82.87 v2(135.62,82.55) ; v2(146.19,40.07) 146.44,39.81 146.44,38.8 146.88,38.36 146.88,37.9 147.11,37.67 JDIM1.98
M_B_A1: length 56.5
  IN1 w0.076: v2(135.62,81.9) 135.39,81.67 135.39,79.92 134.6,79.13 134.6,77.55 134.53,77.48 134.53,76.31
  IN1 w0.14: 134.53,76.31 134.53,75.87 132.39,73.73 132.39,69.02 132.52,68.9 133.01,68.9 133.14,68.77 133.14,68.45 133,68.31 131.87,68.31 131.73,68.17 131.73,67.89 131.87,67.75 133,67.75 133.14,67.61 133.14,67.33 133,67.19 131.87,67.19 131.73,67.05 131.73,66.77 131.87,66.63 133,66.63 133.14,66.49 133.14,66.24 133,66.1 132.38,66.1 132.24,65.96 132.24,65.68 132.38,65.54 133,65.54 133.14,65.4 133.14,59.4 146.13,46.4 146.13,44.89 146.81,44.22 146.81,42.86 146.93,42.73 v2(147.38,42.73)
  BOTTOM w0.165: U14.AR40 135.95,82.22 v2(135.62,81.9) ; JDIM1.97 146.81,43.3 v2(147.38,42.73)
M_B_A2: length 58.2
  IN1 w0.076: 133.46,76.31 133.46,77.51 133.89,77.94 133.89,81.3 134.21,81.62 134.21,82.1 v2(134.71,82.6)
  IN1 w0.14: 133.46,76.31 133.46,76.25 131.36,74.16 131.36,71.59 130.62,70.85 130.62,61.58 130.75,61.45 131.98,61.45 132.11,61.33 132.11,61.09 131.97,60.95 130.78,60.95 130.64,60.81 130.64,60.53 130.78,60.39 131.97,60.39 132.11,60.25 132.11,58.97 144.43,46.65 144.43,45.14 145.44,44.13 145.44,39.22 v2(145.91,38.75)
  BOTTOM w0.165: JDIM1.96 146.51,38.14 v2(145.91,38.75) ; v2(134.71,82.6) 134.98,82.87 U14.AP42
M_B_A3: length 57.1
  IN1 w0.076: v2(134.71,81.95) 134.38,81.62 134.38,81.55 134.12,81.3 134.12,77.84 133.84,77.56 133.84,76.31
  IN1 w0.14: v2(145.91,42.66) 145.91,44.15 144.78,45.28 144.78,46.79 132.45,59.11 132.45,61.69 132.31,61.83 131.11,61.83 130.97,61.97 130.97,62.25 131.11,62.39 132.31,62.39 132.45,62.53 132.45,62.81 132.31,62.95 131.11,62.95 130.97,63.09 130.97,63.37 131.11,63.51 132.31,63.51 132.45,63.65 132.45,63.99 132.32,64.12 131.1,64.12 130.97,64.25 130.97,64.56 131.11,64.7 131.59,64.7 131.73,64.84 131.73,65.12 131.59,65.26 131.11,65.26 130.97,65.4 130.97,70.7 131.71,71.44 131.71,74.01 133.84,76.15 133.84,76.31
  BOTTOM w0.165: v2(134.71,81.95) 134.92,81.95 U14.AR42 ; JDIM1.95 146.21,42.96 v2(145.91,42.66)
M_B_A4: length 63.2
  IN1 w0.076: 133.02,76.31 133.02,79.8 132.8,80.02 132.8,81.97 v2(132.8,81.97)
  IN1 w0.14: 133.02,76.31 133.02,76.29 131.02,74.3 131.02,71.73 130.28,70.99 130.28,60.13 130.41,60.01 131.58,60.01 131.71,59.88 131.71,59.6 131.58,59.47 130.41,59.47 130.28,59.35 130.28,59 130.41,58.87 131.72,58.87 131.92,58.68 131.92,58.48 131.3,57.87 131.3,57.67 131.5,57.47 131.7,57.47 132.31,58.08 132.51,58.08 132.71,57.89 132.71,57.69 132.09,57.08 132.09,56.88 132.29,56.68 132.49,56.68 133.1,57.29 133.3,57.29 133.6,56.99 133.6,56.8 132.96,56.16 132.96,55.96 133.16,55.76 133.36,55.76 133.99,56.4 134.19,56.4 143.52,47.07 143.52,45.56 145.09,43.99 145.09,40.7 v2(144.51,40.12)
  BOTTOM w0.165: v2(132.8,81.97) 133.05,82.22 U14.AR45 ; v2(144.51,40.12) 145.31,39.32 JDIM1.92
M_B_A5: length 61
  IN1 w0.076: 132.55,76.31 132.82,76.58 132.82,79.16 132.41,79.57 132.41,82.23 v2(132.8,82.62)
  IN1 w0.14: 132.55,76.31 130.68,74.44 130.68,71.87 129.94,71.13 129.94,58.48 133.16,55.26 133.38,55.26 134.02,55.89 134.22,55.89 134.43,55.68 134.43,55.48 133.79,54.84 133.79,54.64 133.99,54.45 134.19,54.45 134.83,55.08 135.02,55.08 135.22,54.89 135.22,54.69 134.58,54.05 134.58,53.85 134.78,53.66 134.98,53.66 135.62,54.29 135.81,54.29 136.01,54.1 136.01,53.9 135.37,53.26 135.37,53.06 135.57,52.87 135.77,52.87 136.41,53.5 136.61,53.5 136.8,53.31 136.8,53.11 136.16,52.47 136.16,52.27 136.36,52.07 136.56,52.07 137.2,52.71 137.4,52.71 137.62,52.49 137.62,52.3 136.98,51.66 136.98,51.46 137.17,51.26 137.37,51.26 138.01,51.9 138.21,51.9 143.09,47.02 143.09,45.25 144.64,43.7 v2(144.64,43.27)
  BOTTOM w0.165: v2(144.64,43.27) 144.79,43.27 145.01,43.49 JDIM1.91 ; v2(132.8,82.62) 133.02,82.62 U14.AP45
M_B_A6: length 65.4
  IN1 w0.076: v2(131.82,79.45) 131.81,79.45 131.81,79.46 131.85,79.46 132.51,78.79 132.51,76.76 132.07,76.31
  IN1 w0.14: 132.07,76.31 130.34,74.58 130.34,72.1 129.57,71.33 129.57,58.36 137.14,50.79 137.38,50.79 137.99,51.4 138.23,51.4 138.41,51.22 138.41,51.02 137.75,50.36 137.75,50.16 137.94,49.96 138.14,49.96 138.8,50.62 139,50.62 139.2,50.42 139.2,50.23 138.54,49.56 138.54,49.37 138.73,49.17 138.93,49.17 139.59,49.83 139.79,49.83 139.99,49.63 139.99,49.44 139.33,48.77 139.33,48.58 139.52,48.38 139.72,48.38 140.38,49.04 140.58,49.04 140.78,48.84 140.78,48.65 140.12,47.98 140.12,47.79 140.31,47.59 140.51,47.59 141.17,48.25 141.37,48.25 141.57,48.05 141.57,47.86 140.91,47.19 140.91,47 141.11,46.8 141.3,46.8 141.97,47.46 142.16,47.46 142.73,46.89 142.73,46.22 142.59,46.08 142.29,46.08 142.15,45.94 142.15,45.66 142.29,45.52 142.59,45.52 142.73,45.38 142.73,44.94 144.17,43.49 144.17,42.08 144.31,41.94 144.6,41.94 144.74,41.8 144.74,41.46 144.61,41.34 144.22,41.34 144.1,41.21 144.1,40.49 144.06,40.46 144.06,38.98 144.2,38.85 v2(144.51,38.85)
  BOTTOM w0.165: v2(144.51,38.85) 144.94,38.42 144.94,37.91 144.71,37.68 JDIM1.90 ; v2(131.82,79.45) 131.81,79.45 131.81,79.46 131.95,79.46 U14.AW46
M_B_A7: length 66.3
  IN1 w0.076: 131.05,76.31 131.38,76.64 131.38,77.68 v2(131.81,78.12)
  IN1 w0.14: v2(143.19,39.31) 142.92,39.57 142.92,39.82 143.06,39.96 143.58,39.96 143.72,40.1 143.72,40.38 143.58,40.52 143.06,40.52 142.92,40.66 142.92,40.94 143.06,41.08 143.58,41.08 143.72,41.21 143.72,41.49 143.58,41.63 143.06,41.63 142.92,41.77 142.92,43.77 140.98,45.71 140.12,45.71 139.98,45.85 139.98,46.07 139.84,46.21 139.56,46.21 139.42,46.07 139.42,45.85 139.28,45.71 139.09,45.71 138.95,45.84 138.95,46.32 139.65,47.02 139.65,47.21 139.45,47.41 139.25,47.41 138.43,46.58 138.25,46.58 138.03,46.8 138.03,46.98 138.86,47.81 138.86,48 138.66,48.2 138.46,48.2 137.64,47.37 137.46,47.37 137.24,47.59 137.24,47.77 138.07,48.6 138.07,48.79 137.87,48.99 137.67,48.99 136.39,47.71 136.2,47.71 135.97,47.94 135.97,48.12 136.56,48.7 136.56,48.89 136.24,49.21 136.05,49.21 135.46,48.62 135.27,48.62 135.07,48.82 135.07,49.02 135.65,49.6 135.65,49.8 128.86,56.59 128.86,56.85 129,56.98 129.28,56.98 129.42,57.12 129.42,57.4 129.28,57.54 129,57.54 128.86,57.68 128.86,71.89 129.65,72.68 129.65,74.92 131.05,76.31
  BOTTOM w0.165: JDIM1.86 143.51,37.67 143.67,37.83 143.67,38.82 v2(143.19,39.31) ; v2(131.81,78.12) 131.81,78.09 132.42,78.7 132.42,78.94 U14.AY46
M_B_A8: length 64.5
  IN1 w0.076: 131.58,76.31 132.32,77.05 132.32,78.28 v2(131.84,78.76)
  IN1 w0.14: 131.58,76.31 129.99,74.73 129.99,72.35 129.22,71.58 129.22,58.2 130.05,57.37 130.05,57.17 129.52,56.65 129.52,56.45 129.72,56.25 129.92,56.25 130.44,56.78 130.64,56.78 130.84,56.58 130.84,56.38 130.31,55.86 130.31,55.66 130.51,55.46 130.71,55.46 131.23,55.99 131.43,55.99 131.63,55.79 131.63,55.59 131.1,55.07 131.1,54.87 131.3,54.67 131.5,54.67 132.02,55.2 132.22,55.2 132.42,55 132.42,54.8 131.89,54.28 131.89,54.08 132.09,53.88 132.29,53.88 132.81,54.41 133.01,54.41 133.21,54.21 133.21,54.01 132.68,53.49 132.68,53.29 132.88,53.09 133.08,53.09 133.61,53.62 133.8,53.62 134.01,53.41 134.01,53.21 133.47,52.67 133.47,52.47 133.67,52.28 133.87,52.28 134.41,52.81 134.61,52.81 134.8,52.62 134.8,52.42 134.27,51.88 134.27,51.68 134.46,51.49 134.66,51.49 135.2,52.02 135.4,52.02 135.59,51.83 135.59,51.63 135.06,51.09 135.06,50.89 135.25,50.69 135.45,50.69 135.99,51.23 136.19,51.23 136.38,51.03 136.38,50.84 135.85,50.3 135.85,50.1 136.04,49.9 136.24,49.9 136.78,50.44 136.98,50.44 137.18,50.24 137.18,50.05 136.64,49.51 136.64,49.31 136.84,49.11 137.03,49.11 137.57,49.65 137.77,49.65 141.12,46.3 141.12,46.05 143.26,43.91 143.26,42.79 v2(143.7,42.35)
  BOTTOM w0.165: v2(143.7,42.35) 143.7,42.4 144.19,42.89 144.19,43.53 144.41,43.75 JDIM1.89 ; v2(131.84,78.76) 131.49,79.11 U14.AY47
M_B_A9: length 67.4
  IN1 w0.076: 130.56,78.5 131.39,79.32 131.39,80.3 131.85,80.76 v2(131.85,80.76)
  IN1 w0.14: 130.56,78.5 130.34,78.27 130.34,77.93 129.27,76.86 129.27,76.24 126.79,73.77 126.79,62.36 126.93,62.22 127.5,62.22 127.64,62.08 127.64,61.8 127.5,61.66 126.93,61.66 126.79,61.52 126.79,61.24 126.93,61.1 127.5,61.1 127.64,60.96 127.64,60.68 127.5,60.54 126.93,60.54 126.79,60.4 126.79,60.12 126.93,59.98 127.5,59.98 127.64,59.84 127.64,59.56 127.5,59.42 126.93,59.42 126.79,59.28 126.79,59 126.93,58.86 127.5,58.86 127.64,58.72 127.64,58.44 127.5,58.3 126.93,58.3 126.79,58.16 126.79,57.89 126.93,57.75 127.5,57.75 127.64,57.61 127.64,57.33 127.5,57.19 126.93,57.19 126.79,57.05 126.79,56.77 126.93,56.63 127.5,56.63 127.64,56.49 127.64,56.21 127.5,56.07 126.96,56.07 126.83,55.94 126.83,55.66 126.96,55.53 127.49,55.53 127.69,55.34 127.69,54.63 129.16,53.16 129.16,52.96 128.87,52.68 128.87,52.48 129.07,52.28 129.27,52.28 129.55,52.57 129.75,52.57 129.95,52.37 129.95,52.17 129.66,51.89 129.66,51.69 129.86,51.49 130.06,51.49 130.34,51.78 130.54,51.78 130.82,51.5 130.82,51.3 130.53,51.02 130.53,50.82 130.73,50.62 130.93,50.62 131.22,50.91 131.41,50.91 131.61,50.71 131.61,50.51 131.32,50.23 131.32,50.03 131.52,49.83 131.72,49.83 132.01,50.12 132.2,50.12 132.4,49.92 132.4,49.72 132.11,49.43 132.11,49.24 132.31,49.04 132.51,49.04 132.8,49.33 132.99,49.33 133.19,49.13 133.19,48.93 132.9,48.64 132.9,48.45 133.1,48.25 133.3,48.25 133.59,48.54 133.78,48.54 136.14,46.18 137.16,46.18 138.66,44.68 140.13,44.68 141.16,43.65 141.16,43.04 142.12,42.07 v2(142.12,41.95)
  BOTTOM w0.089: U14.AU46 132.15,81.06 v2(131.85,80.76)
  BOTTOM w0.165: v2(142.12,41.95) 142.12,42.56 143.21,43.65 JDIM1.85
M_B_A10: length 71.1
  IN1 w0.076: 136.81,76.17 136.81,78.78 137.55,79.52 137.55,82.54 137.51,82.58 137.51,84.61 v2(138.01,85.1)
  IN1 w0.14: 136.81,76.17 136.81,75.17 136.51,74.87 136.51,61.58 136.62,61.46 136.98,61.11 136.98,60.83 136.43,60.29 136.43,60.11 136.67,59.87 136.85,59.87 137.42,60.45 137.62,60.45 137.82,60.25 137.82,60.05 137.26,59.49 137.26,59.29 137.45,59.1 137.65,59.1 138.21,59.66 138.41,59.66 138.61,59.46 138.61,59.26 138.05,58.7 138.05,58.5 138.25,58.31 138.44,58.31 139,58.86 139.2,58.86 139.4,58.67 139.4,58.47 138.53,57.6 138.53,57.42 138.75,57.21 138.93,57.21 139.79,58.07 139.99,58.07 140.19,57.88 140.19,57.68 139.32,56.81 139.32,56.63 139.66,56.3 139.84,56.3 140.71,57.17 140.89,57.17 141.11,56.96 141.11,56.78 140.24,55.91 140.24,55.71 140.44,55.52 140.64,55.52 141.21,56.09 141.41,56.09 141.61,55.89 141.61,55.7 141.03,55.12 141.03,54.92 141.49,54.47 141.68,54.47 141.83,54.61 142.03,54.61 142.22,54.42 142.22,54.22 142.08,54.07 142.08,53.88 142.28,53.68 142.47,53.68 142.62,53.82 142.82,53.82 143.01,53.63 143.01,53.43 142.87,53.28 142.87,53.09 143.07,52.89 143.26,52.89 143.41,53.03 143.61,53.03 143.8,52.84 143.8,52.64 143.66,52.49 143.66,52.3 143.86,52.1 144.05,52.1 144.2,52.24 144.4,52.24 144.6,52.05 144.6,51.85 144.45,51.7 144.45,51.51 144.65,51.31 144.85,51.31 144.99,51.45 145.19,51.45 145.39,51.26 145.39,51.06 145.24,50.91 145.24,50.72 145.47,50.48 145.67,50.48 145.83,50.64 146.02,50.64 146.22,50.44 146.22,50.25 146.06,50.09 146.06,49.89 146.26,49.69 146.46,49.69 146.62,49.85 146.81,49.85 147.01,49.65 147.01,49.46 146.85,49.3 146.85,49.1 147.05,48.9 147.25,48.9 147.41,49.06 147.6,49.06 147.8,48.86 147.8,48.67 147.64,48.51 147.64,48.31 147.96,48 148.16,48 148.31,48.16 148.51,48.16 148.71,47.96 148.71,47.76 148.54,47.59 148.54,47.41 148.76,47.19 148.94,47.19 149.12,47.37 149.3,47.37 149.47,47.19 149.47,47.01 149.06,46.6 149.06,45.53 150.43,44.17 v2(150.43,43.22)
  BOTTOM w0.165: JDIM1.107 149.81,43.83 v2(150.43,43.22) ; U14.AK36 138.38,85.47 v2(138.01,85.1)
M_B_A11: length 67.3
  IN1 w0.14: v2(143.19,38.04) 142.58,38.64 142.58,43.62 140.84,45.36 138.95,45.36 137.45,46.86 136.51,46.86 134.5,48.87 134.5,49.07 135.09,49.67 135.09,49.87 134.89,50.06 134.7,50.06 134.1,49.47 133.9,49.47 133.71,49.66 133.71,49.86 134.3,50.46 134.3,50.66 134.1,50.85 133.91,50.85 133.31,50.26 133.11,50.26 132.91,50.45 132.91,50.65 133.51,51.25 133.51,51.45 133.31,51.64 133.12,51.64 132.52,51.05 132.32,51.05 132.12,51.25 132.12,51.44 132.72,52.04 132.72,52.24 132.52,52.43 132.33,52.43 131.73,51.84 131.53,51.84 131.33,52.04 131.33,52.23 131.93,52.83 131.93,53.03 131.65,53.3 131.46,53.3 130.83,52.68 130.63,52.68 130.43,52.87 130.43,53.07 131.06,53.7 131.06,53.9 130.86,54.09 130.66,54.09 130.04,53.47 129.84,53.47 129.64,53.66 129.64,53.86 130.27,54.49 130.27,54.69 130.07,54.89 129.87,54.89 129.25,54.26 129.05,54.26 128.85,54.45 128.85,54.65 129.48,55.28 129.48,55.48 128.43,56.53 128.43,74.43 130.06,76.06 130.06,76.69 v2(130.89,77.53)
  BOTTOM w0.076: U14.AV47 131.13,80.12 131.13,78.82 131.33,78.62 131.33,77.96 v2(130.89,77.53)
  BOTTOM w0.165: JDIM1.84 142.91,37.76 v2(143.19,38.04)
M_B_A12: length 62.9
  IN1 w0.14: v2(130.89,78.17) 129.61,76.88 129.61,76.1 128.03,74.52 128.03,73.51 127.89,73.37 127.28,73.37 127.14,73.23 127.14,72.95 127.28,72.81 127.89,72.81 128.03,72.67 128.03,72.39 127.89,72.25 127.28,72.25 127.14,72.11 127.14,71.83 127.28,71.69 127.89,71.69 128.03,71.55 128.03,71.27 127.89,71.14 127.28,71.14 127.14,71 127.14,70.72 127.28,70.58 127.89,70.58 128.03,70.44 128.03,70.16 127.89,70.02 127.28,70.02 127.14,69.88 127.14,69.6 127.28,69.46 127.89,69.46 128.03,69.32 128.03,69.04 127.89,68.9 127.28,68.9 127.14,68.76 127.14,68.48 127.28,68.34 127.89,68.34 128.03,68.2 128.03,67.92 127.89,67.78 127.28,67.78 127.14,67.64 127.14,67.36 127.28,67.22 127.89,67.22 128.03,67.08 128.03,66.78 127.89,66.64 127.28,66.64 127.14,66.5 127.14,66.22 127.28,66.08 127.89,66.08 128.03,65.94 128.03,65.66 127.89,65.52 127.28,65.52 127.14,65.38 127.14,65.1 127.28,64.96 127.89,64.96 128.03,64.82 128.03,64.54 127.89,64.4 127.28,64.4 127.14,64.26 127.14,63.98 127.28,63.84 127.89,63.84 128.03,63.7 128.03,63.43 127.89,63.29 127.28,63.29 127.14,63.15 127.14,62.87 127.28,62.73 127.89,62.73 128.03,62.59 128.03,54.78 136.29,46.52 137.3,46.52 138.8,45.02 140.38,45.02 140.38,45.01 v2(142.12,43.27)
  BOTTOM w0.076: v2(130.89,78.17) 130.96,78.23 130.96,80.42 131.37,80.83 U14.AU47
  BOTTOM w0.165: v2(142.12,43.27) 142.61,43.76 JDIM1.83
M_B_A13: length 71.6
  IN1 w0.076: 140.57,81.85 140.53,81.88 140.53,84.63 v2(139.95,85.21)
  IN1 w0.14: v2(152.13,40.77) 152.13,37.3 152.26,37.17 153.44,37.17 153.56,37.3 153.56,39.26 153.7,39.4 154.28,39.4 154.41,39.54 154.41,39.82 154.28,39.96 153.7,39.96 153.56,40.09 153.56,40.37 153.7,40.51 154.28,40.51 154.41,40.65 154.41,40.93 154.28,41.07 153.7,41.07 153.56,41.21 153.56,44.5 154.08,45.02 154.08,48.17 138.84,63.41 138.84,73.5 139.63,74.29 139.63,77.25 140.98,78.6 140.98,79.46 141.11,79.59 142.48,79.59 142.6,79.72 142.6,80.12 142.48,80.25 141.08,80.25 140.9,80.43 140.9,80.92 140.57,81.26 140.57,81.85
  BOTTOM w0.165: U14.AK33 140.16,85.21 v2(139.95,85.21) ; v2(152.13,40.77) 152.13,40.8 153.41,42.09 JDIM1.119
M_B_A14: length 68.4
  IN1 w0.076: 130.39,78.65 131.19,79.45 131.19,80.71 131.85,81.37 v2(131.85,82.03)
  IN1 w0.14: 130.39,78.65 130.06,78.32 130.06,77.99 128.91,76.85 128.91,76.39 126.45,73.93 126.45,72.95 126.31,72.81 125.65,72.81 125.51,72.67 125.51,72.39 125.65,72.25 126.31,72.25 126.45,72.11 126.45,71.83 126.31,71.69 125.65,71.69 125.51,71.55 125.51,71.27 125.65,71.13 126.31,71.13 126.45,70.99 126.45,70.71 126.31,70.57 125.65,70.57 125.51,70.43 125.51,70.15 125.65,70.01 126.31,70.01 126.45,69.87 126.45,69.6 126.31,69.46 125.65,69.46 125.51,69.32 125.51,69.04 125.65,68.9 126.31,68.9 126.45,68.76 126.45,68.33 126.31,68.19 125.62,68.19 125.48,68.05 125.48,67.77 125.62,67.63 126.31,67.63 126.45,67.49 126.45,67.21 126.31,67.07 125.62,67.07 125.48,66.93 125.48,66.65 125.62,66.51 126.31,66.51 126.45,66.37 126.45,54.4 126.92,53.92 127.12,53.92 127.39,54.19 127.59,54.19 127.79,54 127.79,53.8 127.52,53.53 127.52,53.33 127.71,53.13 127.91,53.13 128.18,53.4 128.38,53.4 128.58,53.2 128.58,53.01 128.31,52.74 128.31,52.54 133.26,47.59 134.25,47.59 136,45.83 137.02,45.83 138.52,44.33 139.99,44.33 140.81,43.51 140.81,42.9 141.32,42.39 141.32,41.18 142.2,40.3 142.2,38.57 v2(141.71,38.09)
  BOTTOM w0.165: v2(131.85,82.03) 132.04,82.22 U14.AR46 ; JDIM1.80 v2(141.71,38.09)
M_B_A15: length 67.9
  IN1 w0.076: v2(131.85,82.68) 131.45,82.28 131.45,81.67 130.86,81.07 130.86,79.43 129.7,78.27 129.7,77.91 128.1,76.31
  IN1 w0.14: 128.1,76.31 125.14,73.35 125.14,66.11 125.28,65.97 125.95,65.97 126.09,65.83 126.09,65.55 125.95,65.41 125.28,65.41 125.14,65.27 125.14,64.99 125.28,64.85 125.95,64.85 126.09,64.71 126.09,64.44 125.95,64.3 125.28,64.3 125.14,64.16 125.14,63.88 125.28,63.74 125.95,63.74 126.09,63.6 126.09,63.32 125.95,63.18 125.28,63.18 125.14,63.04 125.14,62.76 125.28,62.62 125.95,62.62 126.09,62.48 126.09,62.2 125.95,62.06 125.28,62.06 125.14,61.92 125.14,61.64 125.28,61.5 125.95,61.5 126.09,61.36 126.09,61.08 125.95,60.94 125.28,60.94 125.14,60.8 125.14,60.52 125.28,60.38 125.95,60.38 126.11,60.23 126.11,54.26 133.12,47.24 134.11,47.24 134.87,46.48 134.87,46.28 134.58,46 134.58,45.8 134.78,45.6 134.98,45.6 135.26,45.89 135.46,45.89 135.86,45.49 136.88,45.49 138.38,43.99 139.85,43.99 140.47,43.37 140.47,42.56 140.88,42.15 140.88,40.19 v2(141.71,39.36)
  BOTTOM w0.165: JDIM1.78 141.11,38.76 v2(141.71,39.36) ; v2(131.85,82.68) 132.04,82.87 U14.AP46
