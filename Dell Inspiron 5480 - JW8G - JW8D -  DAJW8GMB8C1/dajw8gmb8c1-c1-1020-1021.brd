# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP7+: length 231
  TOP w0.114: L4.3 18.82,107.07 18.4,106.64 18.17,106.64 v2(18,106.81)
  IN1 w0.076: 152.17,86.98 152.18,86.97 152.18,86.9 152.31,86.78 152.31,86.37 151.95,86.02 151.95,85.74 152.13,85.56 152.13,83.55 152.61,83.07 152.69,83.07 v2(152.95,83.33)
  IN1 w0.102: v2(18,106.81) 18.38,106.43 19.14,106.43 19.69,105.88 19.69,102.2 17.2,99.71 17.2,86.94 17.65,86.5 17.65,73.21 19.15,71.71 19.15,60.18 20.57,58.76 20.57,56.8 22.88,54.49 26.98,54.49 27.2,54.28 29.66,54.28 30.34,53.61 33.29,53.61 40.3,46.6 45.93,46.6 48.14,44.39 60.87,44.39 63.13,42.12 63.85,42.12 65.13,40.84 79.93,40.84 81.61,42.52 94.33,42.52 100.61,48.79 103.26,48.79 106.4,51.93 108.95,51.93 112.77,55.75 112.77,56.47 115.04,58.75 115.04,63.95 115.24,64.14 115.24,73.67 120.18,78.61 120.18,84.16 120.76,84.75 121.65,84.75 122.82,85.91 126.18,85.91 126.86,86.59 129.75,86.59 131.71,88.54 146.84,88.54 147.61,87.78 148.43,87.78 148.85,87.36 151.79,87.36 152.17,86.98
  BOTTOM w0.114: v2(152.95,83.33) 152.64,83.01 U14.AP13
USBP7+_TSCR: length 4.5
  TOP w0.114: L4.4 21.1,107.07 21.51,106.65 21.97,106.65 22.15,106.48 22.59,106.03 v2(22.94,106.03)
  BOTTOM w0.114: v2(22.94,106.03) 23.18,105.8 23.66,105.8 23.8,105.95 CN1.2
USBP7-: length 231.1
  TOP w0.114: L4.2 18.54,106.27 18.42,106.39 18.35,106.39 18,106.04 v2(18,106.01)
  IN1 w0.076: 152,86.81 152,86.8 152.07,86.8 152.15,86.71 152.15,86.43 151.8,86.08 151.8,85.67 151.98,85.5 151.98,83.49 152.55,82.91 152.69,82.91 152.95,82.66 v2(152.97,82.66)
  IN1 w0.102: 152,86.81 151.69,87.12 148.75,87.12 148.33,87.54 147.51,87.54 146.74,88.3 131.81,88.3 129.85,86.35 126.96,86.35 126.28,85.67 122.92,85.67 121.75,84.5 120.86,84.5 120.42,84.06 120.42,78.51 115.48,73.57 115.48,64.04 115.29,63.85 115.29,58.65 113.01,56.37 113.01,55.65 109.05,51.69 106.5,51.69 103.36,48.55 100.71,48.55 94.43,42.28 81.71,42.28 80.03,40.6 65.03,40.6 63.75,41.88 63.03,41.88 60.77,44.14 48.04,44.14 45.83,46.35 40.2,46.35 33.19,53.36 30.24,53.36 29.56,54.04 27.1,54.04 26.88,54.25 22.78,54.25 20.33,56.7 20.33,58.66 18.91,60.08 18.91,71.61 17.41,73.11 17.41,86.4 16.96,86.84 16.96,99.81 19.45,102.3 19.45,105.78 19.04,106.19 18.18,106.19 v2(18,106.01)
  BOTTOM w0.114: U14.AR13 152.57,82.57 152.71,82.71 152.91,82.71 v2(152.97,82.66)
USBP7-_TSCR: length 4.5
  TOP w0.114: v2(22.94,105.37) 22.89,105.37 22.41,105.86 21.87,106.39 21.28,106.39 21.15,106.27 L4.1
  BOTTOM w0.114: v2(22.94,105.37) 23.12,105.55 23.68,105.55 23.78,105.45 CN1.3
USBPLLMON_N: length 7.4
  TOP w0.254: R108.1 155.08,77.69 v1(155.08,78.42) 155.08,79.72 154.41,80.38 154.41,82.92 154.82,83.32 v2(154.9,83.32)
  BOTTOM w0.254: v2(154.9,83.32) 154.82,83.32 U14.AN10
USBPLLMON_P: length 9.5
  TOP w0.254: v1(153.45,76.15) 153.45,76.26 154.4,77.21 R107.1 154.41,77.84 154.03,78.22 154.03,83.43 154.59,83.98 v2(154.9,83.98)
  BOTTOM w0.254: v2(154.9,83.98) 154.81,83.98 U14.AM10
VCHGR_ACDET: length 6.8
  TOP w0.254: PU3.6 50.05,27.29 51.17,26.18 PC58.2 51.17,25.67 51.54,25.3 51.54,24.9 51.75,24.7 v1(52.08,24.7) 52.75,24.7 PR94.2 53.09,25.05 PR87.1
VCHGR_BST: length 5.4
  TOP w0.102: PD2.1 43.8,31.08 v1(43.59,31.28)
  TOP w0.279: PU3.17 45.3,28.79 45.1,28.99 44.7,28.99 44.13,28.42
  TOP w0.508: PD2.1 44.13,29.5 PR72.1
VCHGR_DH: length 9
  TOP w0.102: v1(38.46,31.58) 38.46,31.46 v3(38.01,31)
  TOP w0.279: v3(45.01,28.3) 45.01,28.29 PU3.18
  IN3 w0.762: 38.65,30.4 42.34,30.4 44.44,28.3 v3(45.01,28.3)
  vias: v3(38.01,30.24)
VCHGR_DL: length 11.2
  TOP w0.102: v1(37.25,34.74) 37.25,33.99 v3(37.27,33.97)
  TOP w0.279: v3(45.96,30.68) 46.49,30.68 46.73,30.43 PU3.15
  IN3 w0.762: v3(45.96,30.68) 45.11,30.68 43.8,31.99 41.51,31.99 39.99,33.51 37.96,33.51
  vias: v3(37.27,33.21)
VCHGR_LX: length 12.4
  TOP w0.102: v1(37.04,32.07) 37.24,31.86 v2(37.24,31.18)
  TOP w0.254: v3(45.06,27.39) 44.78,27.11 PC54.1
  TOP w0.279: PU3.19 45.46,27.79 v3(45.06,27.39)
  TOP w0.508: PC56.1 35.76,31.18 v2(37.24,31.18)
  IN3 w0.762: v3(38.18,29.3) v3(39.1,29.3) 41.92,29.3 43.82,27.39 v3(45.06,27.39)
VCHGR_PG: length 6.7
  TOP w0.102: PR96.2 48.91,24.79 47.99,23.86 v1(47.86,23.86)
  TOP w0.254: PR96.2 48.91,25.89 48.73,26.08 PU3.5 49.86,26.57 50.48,25.96 PQ16.5
VCHGR_VCC: length 6
  TOP w0.102: PC64.1 45.41,25.63 v1(45.04,26)
  TOP w0.254: PC64.1 44.69,24.91 44.24,25.36 PR103.2
  TOP w0.279: PC64.1 46,25.51 PU3.20
VCORE_AGND: length 14.8
  TOP w0.102: v1(117.58,116.93) 117.28,117.23 v2(116.92,117.23)
  TOP w0.305: v2(110.17,120.84) 110.65,120.84 110.97,120.52 SJ1.2
  TOP w0.508: PR13.1 107.86,117.8 v2(107.86,117.11) ; PR18.2 109.2,111.36 v2(109.83,110.73) ; PR17.2 107.68,111.24 v2(107.17,110.73) 106.66,111.24 PR16.2
  BOTTOM w0.178: v2(107.86,117.11) 108.21,117.11 108.56,116.76 PU9.22
  BOTTOM w0.203: v2(110.17,120.84) 110.25,120.92 110.65,120.92 110.8,120.76 PC107.2
  BOTTOM w0.254: v2(116.92,117.23) 116.89,117.2 PC113.2 115.85,117.19 PR159.2
  BOTTOM w0.508: PC136.2 109.83,111.35 v2(109.83,110.73) 109.96,110.6 PR170.2 109.93,110.07 PR171.2 ; PC137.2 107.73,111.36 PR169.2 107.17,110.79 v2(107.17,110.73)
VGA_OVT#: length 32.1
  TOP w0.102: R94.1 178.28,80.7 v2(178.52,80.94) v1(178.52,81.67)
  BOTTOM w0.102: 181.39,81.39 181.34,81.34 181.34,79.03 181.6,78.77 181.6,76.88 179.79,75.07 179.79,72.02 181.1,70.7 185.25,70.7 185.58,71.03 185.58,71.59 186.8,72.81 187.33,72.81 187.71,73.19 Q39.1 ; 181.39,81.39 180.48,81.39 179.82,80.73 178.72,80.73 v2(178.52,80.94) ; 181.39,81.39 185.48,81.39 186.06,81.98 186.06,82.33 186.8,83.07
  BOTTOM w0.114: U13.A6 186.8,83.07
VGA_PWR_LEVEL: length 94.5
  TOP w0.102: v2(228.71,58.28) 227.19,56.76 v1(227.16,56.76) ; v2(190.39,70.67) 190.53,70.53 190.53,68.69 190.13,68.29 188.91,68.29 188.27,67.65 188.27,66.2 188.2,66.13 Q16.3
  IN2 w0.114: v2(190.39,70.67) 190.39,71.09 190.79,71.49 190.79,72.4 191.12,72.73 192.36,72.73 193.1,73.47 194.29,73.47 199.04,78.22 201.68,78.22 210.39,69.51 221.17,69.51 222.69,67.98 226.5,67.98 226.91,67.57 226.91,62.15 228.71,60.34 v2(228.71,58.28)
  BOTTOM w0.102: PR178.1 229.22,58.79 v2(228.71,58.28) ; U13.D7 187.6,85.54 187.18,85.13 187.18,82.19 185.88,80.89 182.86,80.89 182.35,80.37 R372.1 182.35,79.01 182.76,78.6 183.22,78.6 183.94,77.88 184.41,77.88 184.68,77.61 186.16,77.61 186.39,77.38 186.39,76.36 187.46,75.3 187.46,75.02 187.79,74.69 188.45,74.69 188.81,74.33 188.81,72.78 188.43,72.4 188.43,71.55 189.31,70.67 v2(190.39,70.67)
VGA_PWR_LEVEL_EC: length 55.7
  TOP w0.102: v2(190.08,65.57) 190.05,65.57 189.64,65.16 189.64,64.81 188.53,63.69 188.07,63.69 187.54,63.16 Q16.2
  BOTTOM w0.102: v2(190.08,65.57) 189.01,64.5 189.01,63.28 191.96,60.34 191.96,56.81 192.39,56.37 192.77,56.37 193.1,56.7 193.96,56.7 194.67,55.99 194.67,54.8 195.18,54.29 196.59,54.29 v1(197.18,53.7) 198.11,53.7 199.86,51.96 199.86,49.59 200.69,48.75 200.69,47.18 202.12,45.76 207.07,45.76 209.28,43.55 209.28,41.94 210.27,40.95 216.94,40.95 218.19,42.2 218.19,43.5 218.98,44.29 U23.32
VGA_RST#: length 10.1
  TOP w0.102: R30.1 C30.1 181.48,101.98 v2(181.59,101.87) 182.08,101.87 v1(182.35,102.14)
  BOTTOM w0.102: U13.AC7 187.28,101.4 186.94,101.74 186.08,101.74 186.04,101.79 184.2,101.79 183.88,101.46 183.88,101.19 183.66,100.97 182.56,100.97 182.41,100.82 182,100.82 181.59,101.23 v2(181.59,101.87)
VGA_THERMDN: length 36
  TOP w0.254: C147.2 v1(190.83,87.34) v2(191.34,86.83) ; v2(181.11,65.65) 181.08,65.62 181.08,65.07 181.75,64.4 182.28,64.4 182.32,64.45 U4.3
  IN3 w0.254: v2(191.34,86.83) 190.74,86.23 190.74,84.05 190.03,83.35 187.6,83.35 186.76,84.19 185.33,84.19 184.2,83.05 184.2,81.34 183.55,80.69 183.55,77.34 184.06,76.83 184.06,75.2 183.12,74.26 183.12,73.47 184.29,72.3 184.29,69.02 181.61,66.34 181.61,66.34 181.11,65.85 v2(181.11,65.65)
  BOTTOM w0.254: U13.E12 191.76,86.41 v2(191.34,86.83)
VGA_THERMDP: length 39.4
  TOP w0.254: v2(192.17,86.83) 191.61,87.39 C147.1 ; U4.2 182.35,63.8 182.26,63.89 181.54,63.89 180.58,64.86 180.58,66.05 v2(180.65,66.13)
  IN3 w0.254: v2(180.65,66.13) 180.66,66.12 181.4,66.85 181.4,66.85 183.78,69.23 183.78,72.09 182.61,73.26 182.61,74.47 183.55,75.41 183.55,76.62 183.04,77.13 183.04,80.9 183.69,81.55 183.69,83.27 185.12,84.7 186.98,84.7 187.81,83.86 189.82,83.86 190.23,84.26 190.23,86.93 190.79,87.49 191.83,87.49 192.17,87.15 v2(192.17,86.83)
  BOTTOM w0.254: U13.F12 v2(192.17,86.83)
VGPU_CORE_SENSE: length 102.9
  TOP w0.254: v2(236.41,47.1) 236.41,46.45 234.96,44.99 232.47,44.99 231.02,46.44 221.67,46.44 220.02,44.79 201.18,44.79 198.92,47.05 v1(198.92,53.07) 198.92,55.56 194.8,59.68 194.8,61.2 PR31.2 195.21,61.35 v2(195.49,61.63)
  IN3 w0.254: v2(183.12,87.69) 183.4,87.41 183.4,85.94 182.25,84.8 181.92,84.8 181.58,84.45 181.58,82.32 181.85,82.05 181.85,76.95 181.85,76.72 181.36,76.24 181.36,70.64 179.28,68.56 179.28,64.73 182.54,61.48 195.33,61.48 v2(195.49,61.63)
  BOTTOM w0.102: v2(183.12,87.69) 183.5,87.31 U13.F2
  BOTTOM w0.254: PR192.1 236.73,46.22 236.41,46.54 v2(236.41,47.1)
VMA_CLKN0: length 40.9
  TOP w0.102: v2(217.89,79.15) 217.82,79.08 217.13,79.08 216.97,79.24 216.97,80.14 216.32,80.79 VRAM2.K7
  IN1 w0.102: v2(202.92,86) 202.85,86.07 202.65,86.07 202.5,85.91 202.5,85.78 202.77,85.51 203.82,85.51 205.49,83.83 207.15,83.83 207.93,84.62 208.96,84.62 211.7,81.88 211.7,81.57 211.06,80.93 211.06,80.79 211.35,80.5 211.49,80.5 212.36,81.37 212.94,81.37 213.27,81.04 213.27,77.96 213.85,77.38 216.31,77.38 216.57,77.63 216.57,78.67 216.81,78.9 217.64,78.9 v2(217.89,79.15) 218.11,78.93 218.44,78.93 218.97,78.4 220.12,78.4 221.34,79.62 222.79,79.62 223.55,78.85 224.19,78.85 v2(224.39,79.06)
  BOTTOM w0.114: v2(217.89,79.15) 217.89,79.15 217.98,79.06 218.13,79.06 218.33,79.26 218.33,79.83 218.98,80.47 219.38,80.47 219.51,80.61 VRAM4.K7
  BOTTOM w0.127: v2(224.39,79.06) 224.62,78.83 225.01,78.83 225.3,79.12 R378.1 ; U13.D25 202.52,85.6 v2(202.92,86)
VMA_CLKN1: length 45.8
  TOP w0.102: v2(218.01,104.55) 218.1,104.63 218.64,104.63 218.85,104.42 218.85,104.1 218.72,103.96 218.72,103.56 219.51,102.77 VRAM1.K7
  TOP w0.127: v2(223.91,104.96) 223.91,105 224.2,105.29 224.61,105.29 R23.1
  IN1 w0.102: v2(223.91,104.96) 223.71,105.17 223.56,105.17 222.33,103.94 221.01,103.94 220.29,103.21 219.66,103.21 219.26,103.61 219.26,104.09 218.59,104.76 218.22,104.76 v2(218.01,104.55) 217.78,104.79 217.67,104.79 217.41,104.52 217.41,103.99 217.06,103.64 215.8,103.64 215.37,104.08 214.8,104.08 214.11,103.39 213.19,103.39 212.95,103.15 212.64,103.15 212.17,103.62 212.03,103.62 211.74,103.33 211.74,103.19 212.21,102.72 212.21,102.41 211.69,101.89 211.69,101.12 211.45,100.87 210.78,100.87 210.65,100.75 210.65,100.04 210.78,99.91 211.47,99.91 211.72,99.66 211.72,98.89 211.47,98.64 210.55,98.64 210.42,98.51 210.42,95.63 210.1,95.31 207.71,95.31 206.09,93.69 204.38,93.69 204.18,93.48 201.51,93.48 200.97,92.95 200.77,92.95 v2(200.48,92.66)
  BOTTOM w0.102: v2(218.01,104.55) 217.84,104.73 217.69,104.73 217,104.04 217,103.4 216.59,102.98 216.4,102.98 216.32,102.89 VRAM3.K7
  BOTTOM w0.127: U13.M22 200.08,92.26 v2(200.48,92.66)
VMA_CLKP0: length 40.9
  TOP w0.102: v2(217.89,78.52) 217.53,78.88 217.04,78.88 216.77,79.16 216.77,80.05 216.64,80.17 216.47,80.17 VRAM2.J7
  IN1 w0.102: v2(202.1,86.02) 202.29,85.83 202.29,85.69 202.68,85.3 203.73,85.3 205.41,83.63 207.23,83.63 208.02,84.42 208.87,84.42 211.49,81.79 211.49,81.65 210.86,81.02 210.86,80.7 211.26,80.3 211.58,80.3 212.44,81.16 212.85,81.16 213.06,80.95 213.06,77.88 213.77,77.18 216.4,77.18 216.77,77.55 216.77,78.58 216.89,78.7 217.71,78.7 v2(217.89,78.52) 218.1,78.73 218.35,78.73 218.89,78.19 220.21,78.19 221.43,79.41 222.71,79.41 223.47,78.65 224.16,78.65 v2(224.39,78.42)
  BOTTOM w0.114: v2(217.89,78.52) 218.54,79.17 218.54,79.74 219.07,80.26 219.4,80.26 219.51,80.15 VRAM4.J7
  BOTTOM w0.127: U13.D24 201.7,85.62 v2(202.1,86.02) ; v2(224.39,78.42) 224.54,78.57 224.95,78.57 225.19,78.34 R378.2
VMA_CLKP1: length 45.8
  TOP w0.102: VRAM1.J7 219.36,103.31 219.25,103.31 218.92,103.65 218.92,103.88 219.06,104.02 219.06,104.51 218.73,104.84 218.31,104.84 218.01,105.13 v2(218.01,105.21)
  TOP w0.127: R23.2 224.77,105.8 224.52,105.55 223.99,105.55 v2(223.91,105.62)
  IN1 w0.102: v2(223.91,105.62) 223.66,105.37 223.48,105.37 222.25,104.14 220.93,104.14 220.2,103.41 219.74,103.41 219.46,103.69 219.46,104.18 218.68,104.96 218.26,104.96 v2(218.01,105.21) 217.79,104.99 217.58,104.99 217.2,104.61 217.2,104.08 216.98,103.85 215.88,103.85 215.45,104.28 214.71,104.28 214.03,103.59 213.11,103.59 212.87,103.35 212.72,103.35 212.26,103.82 211.95,103.82 211.54,103.41 211.54,103.1 212.01,102.64 212.01,102.49 211.49,101.98 211.49,101.21 211.36,101.08 210.69,101.08 210.45,100.83 210.45,99.95 210.69,99.71 211.39,99.71 211.51,99.58 211.51,98.97 211.39,98.84 210.46,98.84 210.22,98.6 210.22,95.71 210.02,95.51 207.62,95.51 206,93.89 204.3,93.89 204.1,93.69 201.42,93.69 200.89,93.15 200.78,93.15 v2(200.48,93.46)
  BOTTOM w0.102: VRAM3.J7 216.32,103.27 216.41,103.18 216.5,103.18 216.8,103.48 216.8,104.12 217.6,104.93 217.73,104.93 v2(218.01,105.21)
  BOTTOM w0.127: v2(200.48,93.46) 200.46,93.46 U13.N22
VMA_CMD0: length 32.8
  TOP w0.102: VRAM2.L2 220.22,81.62 219.88,81.96 219.39,81.96 219.27,81.83 219.01,81.83 218.78,82.06 217.85,82.06 217.32,81.53 v2(217.21,81.53)
  IN1 w0.114: v2(213.04,87.92) 216.26,87.92 216.39,87.79 216.39,87.44 216.28,87.33 215.03,87.33 214.92,87.21 214.92,86.99 215.03,86.87 216.28,86.87 216.39,86.76 216.39,86.53 216.28,86.41 215.03,86.41 214.92,86.3 214.92,86.07 215.03,85.96 216.28,85.96 216.39,85.84 216.39,82.34 v2(217.21,81.53)
  BOTTOM w0.102: v2(217.21,81.53) 216.7,82.04 216.2,82.04 216.01,82.23 215.8,82.23 215.65,82.08 215.38,82.08 215.31,82.15 215.21,82.15 215.05,81.99 215.05,81.55 215.16,81.44 215.34,81.44 VRAM4.L2
  BOTTOM w0.127: U13.C27 204.12,84.8 ; 204.45,84.8 205.04,84.8 205.24,85 205.62,85 206.08,85.46 208.39,85.46 v1(209.13,86.19) 209.66,86.73 211.31,86.73 212.33,87.74 212.86,87.74 v2(213.04,87.92)
  BOTTOM w0.381: 204.12,84.8 204.45,84.8
VMA_CMD1: length 5.2
  BOTTOM w0.152: TP63.1 207.51,83.98 205.18,83.98 204.73,84.43 203.67,84.43
  BOTTOM w0.381: U13.C26 203.67,84.43
VMA_CMD2: length 39.7
  TOP w0.102: v2(218.9,80.88) 219.09,80.88 219.49,81.28 220.65,81.28 220.78,81.41 220.78,81.83 220.91,81.96 221.34,81.96 221.47,81.83 221.47,81.37 221.11,81.02 VRAM2.K1 221.4,80.81 222.36,81.77 222.54,81.77
  TOP w0.127: 222.54,81.77 v1(224.11,81.77) 225.02,81.77 R86.2
  IN1 w0.102: v2(201.28,86.05) 201.67,86.44 202.91,86.44
  IN1 w0.114: 202.91,86.44 202.91,86.44 203.9,86.44 205.14,85.2 205.93,85.2 206.47,85.75 210.21,85.75 210.56,86.1 212.27,86.1 212.53,85.84 212.53,83.76 212.66,83.63 214.26,83.63 214.7,83.19 214.7,80.12 214.87,79.95 218.55,79.95 218.9,80.3 v2(218.9,80.88)
  BOTTOM w0.102: VRAM4.K1 215.08,81.18 216.52,81.18 216.84,80.86 218.88,80.86 v2(218.9,80.88)
  BOTTOM w0.127: U13.E24 201.68,86.45 v2(201.28,86.05)
VMA_CMD3: length 39.5
  TOP w0.102: VRAM2.K9 214.95,80.81 215.32,81.19 216.78,81.19 216.94,81.03 218.11,81.03 v2(218.53,81.45)
  IN1 w0.114: v2(201.31,86.88) 201.7,87.26 202.27,87.26 202.83,86.7 204.05,86.7 204.28,86.47 209.91,86.47 210.26,86.82 213.14,86.82 213.62,86.35 213.62,86.18 213.3,85.86 213.3,85.7 213.46,85.54 213.62,85.54 213.94,85.86 214.1,85.86 214.27,85.7 214.27,85.54 213.95,85.22 213.95,85.06 214.11,84.89 214.27,84.89 214.59,85.21 214.75,85.21 214.91,85.05 214.91,84.89 214.59,84.57 214.59,84.41 214.76,84.25 214.92,84.25 215.24,84.57 215.4,84.57 215.67,84.3 215.67,81.25 215.96,80.96 218.03,80.96 v2(218.53,81.45)
  BOTTOM w0.102: v2(218.53,81.45) 218.53,81.58 218.63,81.68 219.05,81.68 219.15,81.58 219.15,81.25 219.26,81.15 219.94,81.15 220.07,81.27 221.34,81.27 221.44,81.17 221.44,80.92 221.34,80.81 VRAM4.K9 221.11,80.68 221.32,80.48 222.87,80.48
  BOTTOM w0.127: 222.87,80.48 223.81,80.48 224.16,80.83 225.22,80.83 R369.2 ; v2(201.31,86.88) 201.7,87.26 U13.F24
VMA_CMD4: length 41.9
  TOP w0.102: v2(218.74,95.88) 219.15,95.88 219.51,96.25 219.51,96.5 219.41,96.6 219.28,96.6 219.18,96.7 219.18,96.9 219.28,97.01 219.6,97.01 219.7,97.11 219.7,97.31 219.6,97.41 219.23,97.41 219.13,97.51 219.13,97.77 219.23,97.87 VRAM1.T7 ; VRAM2.T7 216.28,85.65 216.28,86.02 216.44,86.18 216.74,86.18 216.84,86.27 216.84,86.78 217.05,86.99 217.88,86.99 218.04,87.15 218.34,87.15 v2(218.82,87.63)
  IN3 w0.152: v2(218.74,95.88) 218.74,94.75 218.55,94.57 v2(218.55,90.82) 218.75,90.82 218.93,90.64 218.93,90.38 218.55,90 218.55,89.62 218.93,89.24 218.93,88.83 218.55,88.45 218.55,87.89 v2(218.82,87.63)
  BOTTOM w0.102: v2(218.82,87.63) 218.67,87.63 218.57,87.52 218.57,87.27 218.64,87.19 219.55,87.19 219.69,87.05 219.69,86.87 219.56,86.74 219.39,86.74 219.29,86.63 219.29,86.43 219.39,86.33 219.64,86.33 219.74,86.23 219.74,85.84 VRAM4.T7 ; VRAM3.T7 216.32,96.66 216.91,96.07 218.55,96.07 v2(218.74,95.88)
  BOTTOM w0.127: U13.D27 204.74,86.24 207.35,86.24 210.02,88.91 213.04,88.91 213.72,89.6 215.71,89.6 216.04,89.93 v1(216.04,90.51) 216.34,90.82 v2(218.55,90.82)
VMA_CMD5: length 50.7
  TOP w0.102: v2(217.53,88.13) 217.71,88.31 219.51,88.31 220.5,87.32 220.5,87.07 220.4,86.96 220.26,86.96 220.16,86.86 220.16,86.61 220.26,86.51 220.42,86.51 220.53,86.41 220.53,86.2 220.42,86.1 220.26,86.1 220.16,86 220.16,85.77 VRAM2.T2 ; VRAM1.T2 215.73,97.66 215.73,97.39 215.57,97.23 215.39,97.23 215.28,97.12 215.28,96.88 215.4,96.76 215.4,96.58 215.28,96.46 215.28,96.22 215.37,96.13 215.51,96.13 215.82,96.44 215.96,96.44 216.1,96.3 216.1,96.16 215.75,95.81 215.75,95.66 215.86,95.55 216.02,95.55 216.4,95.92 216.74,95.92 216.87,95.8 216.87,95.51 216.74,95.38 v2(216.59,95.38)
  IN3 w0.152: v2(217.53,88.13) 217.64,88.24 217.64,91.37 217.48,91.53 217.33,91.53 217.18,91.37 217.18,90.31 v2(217,90.13) 216.68,90.45 216.68,95.29 v2(216.59,95.38)
  BOTTOM w0.102: VRAM4.T2 215.51,85.8 215.78,86.07 215.78,86.21 215.37,86.62 215.37,86.76 215.52,86.91 215.66,86.91 216.07,86.5 216.21,86.5 216.36,86.64 216.36,86.79 216.04,87.11 216.04,87.25 216.18,87.39 216.32,87.39 216.64,87.07 216.79,87.07 216.93,87.22 217.24,87.22 217.58,87.56 217.58,88.08 v2(217.53,88.13) ; v2(216.59,95.38) 217.05,94.92 218.82,94.92 220.32,96.41 VRAM3.T2
  BOTTOM w0.127: v2(217,90.13) 217,89.52 216.64,89.17 213.9,89.17 213.22,88.48 210.64,88.48 R341.1 210,88.13 v1(209.36,87.49) 207.63,85.76 205.98,85.76 205.44,85.23 203.67,85.23 U13.D26
VMA_CMD6: length 43.3
  TOP w0.102: VRAM1.R3 216.32,98.35 216.65,98.01 216.65,97.86 217,97.51 217.5,97.51 217.79,97.23 v2(217.79,96.72) ; VRAM2.R3 219.42,84.81 218.95,85.28 218.95,85.85 218.8,86 218.12,86 218.01,86.11 218.01,86.36 218.11,86.46 v2(218.24,86.46)
  IN3 w0.102: v2(217.79,96.72) 218.22,96.29 219.02,96.29 219.2,96.11
  IN3 w0.152: 219.2,96.11 219.39,95.92 219.39,94.72 219.29,94.61 v2(219.29,91.45) 219.39,91.35 219.39,87.49 219.01,87.11 218.02,87.11 217.86,86.96 217.86,86.74 218.15,86.46 v2(218.24,86.46)
  BOTTOM w0.102: VRAM3.R3 218.96,98.12 218.96,97.51 218.39,96.94 218,96.94 v2(217.79,96.72) ; VRAM4.R3 216.45,84.81 216.82,85.19 216.94,85.19 217.17,85.41 217.17,85.89 217.42,86.14 217.92,86.14 v2(218.24,86.46)
  BOTTOM w0.127: v2(219.29,91.45) 214.84,91.45 v1(213.8,90.41) 212.73,89.34 209.84,89.34 207.35,86.85 202.94,86.85 U13.F25
VMA_CMD7: length 49.4
  TOP w0.102: VRAM1.R2 215.18,98.34 215.18,97.78 215.07,97.67 215.07,95.7 v1(215.25,95.52) 215.43,95.35 216.05,95.35 216.42,94.97 216.76,94.97 216.85,95.06 216.96,95.06 v2(217.25,95.35) ; VRAM2.R2 220.32,84.96 219.91,85.36 219.91,87.1 218.98,88.03 218.01,88.03 217.63,87.65 v2(217.1,87.65)
  IN1 w0.114: v2(205.29,88.25) 209.48,88.25 210.51,89.28 212,89.28 213.11,90.38 v2(215.27,90.38)
  IN3 w0.152: v2(217.1,87.65) 216.99,87.55 216.42,87.55 216.21,87.75 216.21,88.3 216.09,88.43 215.55,88.43 215.43,88.56 215.43,88.89 215.55,89.01 216.09,89.01 216.21,89.14 216.21,89.47 216.09,89.6 215.4,89.6 215.27,89.72 v2(215.27,90.38) 215.27,95.02 216.13,95.87 216.95,95.87 217.25,95.57 v2(217.25,95.35)
  BOTTOM w0.102: VRAM3.R2 220.32,98.49 219.91,98.08 219.91,96.47 219.71,96.27 219.43,96.27 219.27,96.1 219.27,95.82 218.65,95.2 217.4,95.2 v2(217.25,95.35) ; v2(217.1,87.65) 215.33,87.65 214.51,86.82 214.51,86.53 214.61,86.43 215.01,86.43 215.11,86.33 215.11,84.9 215.19,84.81 VRAM4.R2
  BOTTOM w0.127: v2(205.29,88.25) 204.73,87.69 203.69,87.69 U13.F26
VMA_CMD8: length 46
  TOP w0.102: 202.67,89.75 201.93,89.75 201.91,89.77 201.13,89.77 200.89,89.54 200.89,88.73 200.87,88.71 200.87,88.09 v2(200.46,87.68) ; VRAM1.P3 216.32,99.45 217.1,98.66 217.58,98.66 217.7,98.54 217.84,98.54 218.02,98.71 218.02,98.96 v2(217.87,99.11) ; VRAM2.P3 219.03,84.02 218.9,84.14 218.34,84.14 218.01,83.82 217.65,83.82 217.25,84.22 v2(217.18,84.22)
  TOP w0.127: 202.67,89.75 203.24,89.75 203.89,90.41 v1(211.39,90.41) 212.38,90.41 v2(213.24,91.27)
  IN3 w0.152: v2(217.87,99.11) 217.87,99.02 217.44,98.59 217,98.59 216.14,97.73 215.32,97.73 212.96,95.36 212.96,92.06 213.24,91.78 v2(213.24,91.27) 213.24,91.21 213.44,91.01 213.44,88.83 213.6,88.67 213.6,87.66 215.6,85.66 216.04,85.66 217.18,84.52 v2(217.18,84.22)
  BOTTOM w0.102: VRAM4.P3 216.18,84.02 216.08,83.91 216.08,83.71 216.18,83.61 216.48,83.61 216.74,83.87 216.74,84.46 216.88,84.6 217.08,84.6 217.18,84.5 v2(217.18,84.22) ; VRAM3.P3 219.38,99.47 219.28,99.37 219.28,99.22 219.17,99.11 219.05,99.11 218.98,99.18 218.98,99.44 218.8,99.61 218.27,99.61 218.16,99.51 218.16,99.21 218.06,99.11 v2(217.87,99.11)
  BOTTOM w0.127: U13.F23 200.84,87.3 v2(200.46,87.68)
VMA_CMD9: length 59.7
  TOP w0.102: VRAM1.N3 215.98,100.27 215.88,100.17 215.88,99.9 215.98,99.8 216.45,99.8 216.61,99.64 217.48,99.64 217.76,99.93 v2(217.76,100.07) ; VRAM2.N3 219.41,83.21 219.05,83.58 218.9,83.58 218.8,83.68 218.8,83.84 218.7,83.94 218.54,83.94 218.44,83.84 218.44,83.68 218.34,83.58 218.24,83.58 218.14,83.48 218.14,83.29 218.24,83.19 218.73,83.19 v2(218.81,83.11)
  IN1 w0.114: v2(221.85,91.25) 219.88,89.28 213.19,89.28 212.35,88.44 210.86,88.44 209.61,87.2 202.84,87.2 202.42,87.62 202.01,87.62 201.52,88.11 200.91,88.11 v2(200.47,88.56)
  IN3 w0.152: v2(217.76,100.07) 218.21,100.52 218.8,100.52 222.16,97.17 222.16,93.48 221.85,93.18 v2(221.85,91.25) 221.85,90.84 222.16,90.54 222.16,90.21 222,90.05 221.83,90.05 221.67,89.9 221.67,89.6 221.83,89.44 222,89.44 222.16,89.29 222.16,88.99 222,88.83 221.83,88.83 221.67,88.68 221.67,88.38 221.83,88.23 222,88.23 222.16,88.07 222.16,87.77 222,87.62 221.83,87.62 221.67,87.46 221.67,87.16 221.83,87.01 222,87.01 222.16,86.85 222.16,86.35 218.92,83.11 v2(218.81,83.11)
  BOTTOM w0.102: VRAM3.N3 219.33,100.27 219.23,100.17 219.23,99.85 219.13,99.75 218.95,99.75 218.85,99.85 218.85,100.23 218.66,100.43 217.86,100.43 217.76,100.33 v2(217.76,100.07) ; VRAM4.N3 216.37,83.21 216.92,83.76 218.04,83.76 218.69,83.11 v2(218.81,83.11)
  BOTTOM w0.127: U13.G22 200.06,88.15 v2(200.47,88.56)
VMA_CMD10: length 56.7
  TOP w0.102: v2(218.54,98.1) 218.86,98.1 219.15,98.4 219.15,98.78 219.47,99.1 219.78,99.1 219.97,99.29 219.97,99.64 220.18,99.85 220.37,99.85 220.63,100.1 220.78,100.1 220.91,99.97 220.91,99.75 220.77,99.61 220.77,99.32 220.67,99.22 220.42,99.22 220.32,99.32 VRAM1.P8 ; v2(218.48,85.57) 218.27,85.57 218.01,85.83 218.01,85.83 217.77,86.07 217.76,86.07 217.76,86.08 217.24,86.08 216.36,85.19 216.22,85.19 215.92,84.89 215.92,83.75 215.85,83.68 215.65,83.68 215.51,83.82 VRAM2.P8
  TOP w0.127: v2(220.3,91.5) 217.94,89.14 215.35,89.14 214.56,88.35 v1(209.53,88.35) 206.03,88.35 205.47,87.79 203.79,87.79 203.27,87.27 202.69,87.27 202.26,87.7 v2(201.3,87.7)
  IN3 w0.152: v2(218.48,85.57) 218.89,85.97 219.65,85.97 219.99,86.31 219.99,86.79 220.3,87.11 v2(220.3,91.5) 220.3,96.33 219.84,96.78 219.84,97.29 219.04,98.1 v2(218.54,98.1)
  BOTTOM w0.102: v2(218.48,85.57) 218.5,85.57 219.1,84.96 219.1,84.53 218.98,84.41 218.98,84.27 219.07,84.18 219.19,84.18 219.36,84.35 219.52,84.35 219.74,84.58 219.95,84.58 220.14,84.38 220.36,84.38 220.62,84.64 220.76,84.64 220.91,84.5 220.91,84.41 220.75,84.25 220.75,83.99 220.65,83.89 220.44,83.89 VRAM4.P8 ; VRAM3.P8 215.96,99.02 215.96,98.56 216.18,98.34 216.31,98.34 216.69,97.96 216.69,97.78 217.27,97.2 218.31,97.2 218.55,97.44 218.55,98.09 v2(218.54,98.1)
  BOTTOM w0.127: U13.G23 v2(201.3,87.7)
VMA_CMD11: length 49.6
  TOP w0.102: VRAM1.P7 219.51,99.59 219.39,99.72 219.12,99.72 218.98,99.58 218.98,99.42 219.15,99.24 219.15,99.07 218.95,98.87 218.95,98.71 218.85,98.61 218.52,98.61 218.42,98.71 218.42,98.94 v2(218.57,99.09) ; v2(218.66,84.66) 217.69,84.66 217.52,84.83 216.93,84.83 216.32,84.22 VRAM2.P7
  IN1 w0.114: v2(220.76,90.89) 219.57,89.7 213.01,89.7 212.17,88.86 210.68,88.86 209.65,87.83 205.53,87.83 205.42,87.72 v2(202.9,87.72)
  IN3 w0.102: v2(218.66,84.66) 218.74,84.58 219.1,84.58
  IN3 w0.152: 219.1,84.58 219.21,84.7 219.21,84.98 218.97,85.22 218.97,85.39 219.09,85.51 219.48,85.51 219.62,85.38 219.89,85.38 220.44,85.93 220.44,86.6 220.76,86.92 v2(220.76,90.89) 220.76,96.51 220.3,96.97 220.3,97.62 218.84,99.09 v2(218.57,99.09)
  BOTTOM w0.102: v2(218.66,84.66) 218.66,84.89 218.56,85 218.35,85 218.25,84.89 218.25,84.27 218.68,83.84 219.34,83.84 VRAM4.P7 ; v2(218.57,99.09) 218.19,98.71 216.87,98.71 216.32,99.26 VRAM3.P7
  BOTTOM w0.127: U13.G24 202.08,87.72 v2(202.9,87.72)
VMA_CMD12: length 48.1
  TOP w0.102: v2(217.12,100.07) 216.84,100.07 216.74,100.17 216.74,100.31 216.98,100.54 216.98,100.72 216.83,100.87 216.62,100.87 216.47,100.72 216.23,100.72 216.04,100.52 215.86,100.52 215.76,100.62 215.76,100.77 215.95,100.96 215.95,101.2 215.87,101.28 215.72,101.28 VRAM1.M2 ; v2(217.08,83.31) 217.49,82.9 217.93,82.9 218.02,82.99 218.36,82.99 218.65,82.71 219.04,82.71 219.08,82.75 219.66,82.75 219.99,82.42 VRAM2.M2
  IN3 w0.152: v2(217.08,83.31) 217.07,83.32 216.2,83.32 213.92,85.6 213.75,85.6 212.07,87.27 212.07,88.53 211.74,88.86 v2(211.74,91.27) 211.74,95.87 212.99,97.11 212.99,98 214.56,99.58 215.37,99.58 215.86,100.07 v2(217.12,100.07)
  BOTTOM w0.102: v2(217.12,100.07) 217.68,100.63 218.74,100.63 218.88,100.49 219.25,100.49 219.45,100.69 219.81,100.69 220.2,101.07 VRAM3.M2 ; VRAM4.M2 215.47,82.37 215.22,82.37 215.12,82.47 215.12,82.6 214.91,82.8 214.91,82.94 215.02,83.06 215.16,83.06 215.34,82.87 215.67,82.87 215.78,82.77 215.78,82.72 215.88,82.62 215.99,82.62 216.2,82.83 216.39,82.83 216.88,83.31 v2(217.08,83.31)
  BOTTOM w0.127: U13.F27 205.25,87.3 205.55,87.59 207.04,87.59 209.53,90.08 211.77,90.08 211.9,90.21 v1(211.9,90.59) 211.9,91.12 v2(211.74,91.27)
VMA_CMD13: length 58.7
  TOP w0.102: VRAM1.L3 216.38,101.87 217.1,102.59 217.56,102.59 v2(217.99,102.15) ; v2(217.89,81.48) 217.89,81.69 218.06,81.86 218.69,81.86 219.1,81.45 219.35,81.45 VRAM2.L3
  TOP w0.127: v2(202.9,88.51) 202.95,88.45 204.05,88.45 204.68,89.09 v1(208.31,89.09) 214.26,89.09 215.04,89.88 215.63,89.88 217.46,91.71 218.55,91.71 218.88,92.04 v2(223.38,92.04)
  IN3 w0.152: v2(217.99,102.15) 218.46,101.69 220.4,101.69 221.46,100.63 221.9,100.63 223.38,99.15 v2(223.38,92.04) 223.38,85.23 222.1,83.96 221.92,83.96 219.86,81.9 218.31,81.9 v2(217.89,81.48)
  BOTTOM w0.102: VRAM4.L3 216.55,81.62 216.72,81.45 216.72,81.27 216.92,81.07 217.58,81.07 217.89,81.38 v2(217.89,81.48) ; v2(217.99,102.15) 217.86,102.02 217.86,101.86 218,101.71 219.35,101.71 VRAM3.L3
  BOTTOM w0.127: U13.G25 v2(202.9,88.51)
VMA_CMD14: length 54.6
  TOP w0.102: VRAM1.M7 219.51,101.34 219.41,101.45 218.17,101.45 v2(217.81,101.09) ; v2(217.58,82.42) 217.58,82.49 217.24,82.83 216.18,82.83 216.09,82.75 216.09,82.64 VRAM2.M7
  IN1 w0.114: v2(222.61,91.17) 221.75,92.04 216.17,92.04 214.94,90.8 212.93,90.8 211.83,89.7 210.34,89.7 209.31,88.67 205.05,88.67 v2(204.63,88.25)
  IN3 w0.102: 219.52,82.64 219.06,82.18 218.36,82.18 218.36,82.18 218.02,82.18 217.78,82.42 v2(217.58,82.42) ; v2(217.81,101.09) 217.9,101.09 218.25,101.44 218.61,101.44 218.88,101.18 219.18,101.18
  IN3 w0.152: 219.52,82.64 222.61,85.73 v2(222.61,91.17) 222.61,98.36 222.03,98.94 221.55,98.94 219.31,101.18 219.18,101.18
  BOTTOM w0.102: VRAM3.M7 216.21,100.96 216.21,100.76 216.31,100.66 216.82,100.66 216.97,100.82 217.54,100.82 v2(217.81,101.09) ; v2(217.58,82.42) 217.87,82.13 219.23,82.13 VRAM4.M7
  BOTTOM w0.127: v2(204.63,88.25) 204.48,88.1 U13.G27
VMA_CMD15: length 51.5
  TOP w0.102: v2(217.48,103.21) 217.56,103.28 217.56,103.64 217.36,103.84 217.12,103.84 217,103.71 217,103.28 216.87,103.15 216.44,103.15 216.32,103.03 VRAM1.K3 ; VRAM2.K3 219.18,80.48 218.41,80.48 218.06,80.82 217.64,80.82 v2(217.26,80.44)
  IN3 w0.152: v2(217.48,103.21) 217.1,103.21 216.78,103.21 216.15,102.58 213.4,102.58 211.9,101.08 211.9,100.36 209.23,97.69 209.23,93.29 208.97,93.04 v2(208.97,90.97) 208.97,85.83 210.71,84.09 211.07,83.73 211.48,83.73 213.61,81.6 214.29,81.6 214.95,80.94 216.16,80.94 216.66,80.44 v2(217.26,80.44)
  BOTTOM w0.102: v2(217.48,103.21) 217.91,102.79 218.28,102.79 218.48,102.98 218.48,102.99 218.71,103.23 219.16,103.23 219.51,102.87 VRAM3.K3 ; v2(217.26,80.44) 217.26,79.72 217.13,79.6 216.96,79.6 216.84,79.72 216.84,80.39 216.72,80.51 216.44,80.51 216.32,80.64 VRAM4.K3
  BOTTOM w0.127: v2(208.97,90.97) 208.97,90.56 v1(208.42,90.01) 206.94,88.53 205.88,88.53 205.72,88.68 204.22,88.68 204.07,88.53 203.73,88.53 U13.G26
VMA_CMD16: length 33.9
  TOP w0.102: VRAM1.L2 215.22,101.87 214.95,101.61 214.95,101.46 215.1,101.31 215.25,101.31 215.43,101.5 217.07,101.5 v2(217.22,101.34)
  IN1 w0.102: 202.13,91.83 v2(202.13,91.83)
  IN1 w0.114: 202.13,91.83 202.51,91.44 203.17,91.44 203.64,91.91 206.99,91.91 208.53,93.45 214.45,93.45 214.57,93.57 214.57,93.79 214.45,93.9 213.81,93.9 213.7,94.02 213.7,94.24 213.81,94.36 214.45,94.36 214.57,94.47 214.57,94.7 214.45,94.82 213.81,94.82 213.7,94.93 213.7,95.16 213.81,95.27 214.45,95.27 214.57,95.39 214.57,97.41 214.56,97.42 214.56,101.11 214.79,101.34 v2(217.22,101.34)
  BOTTOM w0.102: v2(217.22,101.34) 217.39,101.5 219.94,101.5 VRAM3.L2
  BOTTOM w0.127: v2(202.13,91.83) 201.7,92.26 U13.M24
VMA_CMD17: length 2.5
  TOP w0.102: v2(200.48,91.86) 200.48,91.95 200.88,92.35 200.88,93.06 TP46.1
  BOTTOM w0.102: v2(200.48,91.86) 200.88,92.26 U13.M23
VMA_CMD18: length 46.5
  TOP w0.102: VRAM1.K1 215.05,102.34 216.5,102.34 216.95,102.79 218.03,102.79 v2(218.67,102.16)
  IN1 w0.102: v2(202.1,90.16) 201.69,90.57 201.69,91.66 201.7,91.67 201.7,92.01 201.96,92.26 203.31,92.26 203.38,92.19 203.87,92.19 203.98,92.3 204.83,92.3
  IN1 w0.114: v2(218.67,102.16) 218.19,101.68 217.87,101.68 217.79,101.76 217.14,101.76 217.05,101.85 213.72,101.85 213.17,101.29 213.17,99.9 213.28,99.79 214.02,99.79 214.13,99.67 214.13,99.44 214.02,99.33 213.28,99.33 213.17,99.21 213.17,96.74 213.28,96.62 213.97,96.62 214.08,96.51 214.08,96.28 213.97,96.17 213.28,96.17 213.17,96.05 213.17,94.02 213.01,93.86 208.36,93.86 206.97,92.48 205.41,92.48 205.23,92.3 204.83,92.3
  BOTTOM w0.102: 222.61,101.28 222.61,102.67 222.23,103.05 221.36,103.05 221.11,102.81 VRAM3.K1 221.82,102.67 221.92,102.57 221.92,102.31 221.82,102.2 220.7,102.2 220.6,102.31 218.82,102.31 v2(218.67,102.16)
  BOTTOM w0.127: U13.K24 201.7,90.56 v2(202.1,90.16) ; 222.61,101.28 223.48,100.42 224.43,100.42 R303.1
VMA_CMD19: length 42.5
  TOP w0.102: v2(218.88,102.82) 218.88,102.61 219.22,102.27 219.64,102.27 219.8,102.11 220.04,102.11 220.25,102.31 221.16,102.31 221.31,102.16 221.67,102.16 221.77,102.26 221.77,102.57 221.67,102.67 VRAM1.K9 221.11,102.73 221.39,103.01 222.61,103.01
  TOP w0.127: R27.1 223.87,103.88 222.99,103.01 222.61,103.01
  IN1 w0.102: v2(201.3,90.18) 200.89,90.59 200.89,92.04 201.11,92.26 201.47,92.26 201.7,92.5 201.7,92.88
  IN1 w0.114: 201.7,92.88 201.95,93.13 204.3,93.13 204.38,93.2 206.66,93.2 208.05,94.59 212.26,94.59 212.44,94.77 212.44,101.59 213.42,102.58 216.01,102.58 216.14,102.7 218.76,102.7 v2(218.88,102.82)
  BOTTOM w0.102: v2(218.88,102.82) 218.64,102.58 216.81,102.58 216.57,102.34 215.21,102.34 214.88,102.67 VRAM3.K9
  BOTTOM w0.127: U13.K23 v2(201.3,90.18)
VMA_CMD20: length 41.9
  TOP w0.102: v2(217.02,96.53) 217.25,96.53 217.35,96.63 217.35,96.92 217.43,97 217.43,97.18 217.33,97.28 216.92,97.28 216.74,97.11 216.74,96.93 216.64,96.83 216.26,96.83 216.16,96.93 216.16,97.26 216.26,97.36 216.39,97.36 216.49,97.46 216.49,97.7 VRAM1.T3 ; VRAM2.T3 219.51,86.91 219.26,87.17 218.65,87.17 218.43,86.95 218.12,86.95 217.75,86.58 v2(217.33,86.58)
  TOP w0.127: v2(205.42,91.48) 207.35,91.48 208.12,92.25 209.47,92.25 209.91,92.7 v1(210.45,92.7) 212.09,92.7 212.22,92.57 212.22,92.34 212.35,92.21 212.6,92.21 212.73,92.34 212.73,92.57 212.85,92.7 214.69,92.7 214.82,92.57 v2(214.82,92.19)
  IN3 w0.152: v2(217.02,96.53) 216.81,96.33 215.94,96.33 214.82,95.21 214.82,94.9 214.66,94.74 214.49,94.74 214.33,94.59 214.33,94.29 214.49,94.13 214.66,94.13 214.82,93.98 214.82,93.68 214.66,93.53 214.49,93.53 214.33,93.37 214.33,93.07 214.49,92.92 214.66,92.92 214.82,92.76 v2(214.82,92.19) 214.82,89.39 214.97,89.24 214.97,88.35 216.23,87.09 216.82,87.09 v2(217.33,86.58)
  BOTTOM w0.102: v2(217.33,86.58) 217.33,86.41 217.23,86.3 217.05,86.3 216.87,86.48 216.77,86.48 216.51,86.22 216.51,85.97 216.61,85.87 216.87,85.87 216.97,85.77 216.97,85.5 216.86,85.39 216.73,85.39 216.49,85.15 216.22,85.15 216.13,85.24 216.13,85.43 VRAM4.T3 ; VRAM3.T3 219.51,96.86 218.95,96.29 217.26,96.29 v2(217.02,96.53)
  BOTTOM w0.127: v2(205.42,91.48) 204.64,92.26 U13.M27
VMA_CMD21: length 49
  TOP w0.102: v2(215.8,94.9) 215.93,94.77 v1(218.22,94.77) 218.72,94.77 220.32,96.36 VRAM1.T8 ; VRAM2.T8 215.51,86.48 215.62,86.58 215.98,86.58 216.08,86.68 216.08,86.91 215.98,87.02 215.45,87.02 215.34,87.12 215.34,87.35 215.45,87.45 216.56,87.45 216.67,87.55 216.67,87.73 216.56,87.83 215.9,87.83 215.8,87.93 215.8,88.13 215.9,88.23 216.57,88.23 216.67,88.34 v2(216.67,88.48)
  IN1 w0.114: v2(215.83,92.29) 215.27,91.73 213.19,91.73 212.9,92.02 211.96,92.02 211.67,91.73 208.69,91.73 207.53,90.56 204.78,90.56 v2(203.89,91.45)
  IN3 w0.152: v2(216.67,88.48) 216.67,89.7 216.23,90.14 216.23,91.67 215.83,92.06 v2(215.83,92.29) 216.09,92.29 216.23,92.43 216.23,93.33 216.07,93.48 215.88,93.48 215.73,93.63 215.73,93.94 215.88,94.09 216.07,94.09 216.23,94.24 216.23,94.77 216.09,94.9 v2(215.8,94.9)
  BOTTOM w0.102: v2(216.67,88.48) 216.78,88.59 218.82,88.59 220.32,87.1 220.32,86.76 220.42,86.66 220.73,86.66 220.83,86.56 220.83,86.3 220.73,86.2 220.42,86.2 220.32,86.1 VRAM4.T8 ; v2(215.8,94.9) 215.8,95.28 215.68,95.4 215.01,95.4 214.92,95.49 214.92,95.68 215.04,95.8 215.88,95.8 215.98,95.9 215.98,96.11 215.88,96.21 214.98,96.21 214.86,96.33 214.86,96.5 214.98,96.62 215.41,96.62 215.51,96.72 215.51,96.92 215.41,97.02 215.22,97.02 215.12,97.12 215.12,97.33 215.22,97.43 215.41,97.43 215.51,97.53 VRAM3.T8
  BOTTOM w0.127: U13.M26 203.3,92.25 203.89,91.65 v2(203.89,91.45)
VMA_CMD22: length 47
  TOP w0.102: v2(218.17,87.6) 217.79,87.22 216.92,87.22 215.91,86.21 215.91,85.43 215.73,85.24 215.33,85.24 215.23,85.14 215.23,84.92 215.33,84.81 VRAM2.R8 ; VRAM1.R8 220.32,98.34 219.96,97.98 219.96,96.36 219.05,95.46 218.04,95.46 v2(217.88,95.61)
  TOP w0.127: v2(217.89,92.87) 217.38,93.38 v1(208.82,93.38) 208.24,93.38 206.84,91.98 203.03,91.98 v2(202.9,91.85)
  IN3 w0.152: v2(217.88,95.61) 217.88,95.01 217.76,94.88 217.28,94.88 217.15,94.75 217.15,94.52 217.28,94.4 217.94,94.4 218.07,94.27 218.07,93.74 217.94,93.61 217.33,93.61 217.2,93.48 217.2,93 217.33,92.87 v2(217.89,92.87) 218.09,92.67 218.09,87.68 v2(218.17,87.6)
  BOTTOM w0.102: VRAM4.R8 220.06,84.81 219.96,84.92 219.96,87.08 219,88.03 218.57,88.03 218.17,87.63 v2(218.17,87.6) ; v2(217.88,95.61) 217.68,95.81 216.69,95.81 215.91,96.59 215.91,98.17 215.81,98.28 215.47,98.28 215.37,98.38 215.37,98.53 VRAM3.R8
  BOTTOM w0.127: v2(202.9,91.85) 202.5,92.25 U13.M25
VMA_CMD23: length 39.7
  TOP w0.102: v2(218.15,97.6) 218.15,97.3 218.29,97.16 218.6,97.16 218.76,97.32 218.76,97.71 219.51,98.47 VRAM1.R7 ; VRAM2.R7 216.38,84.75 216.56,84.75 216.69,84.88 216.69,85.22 216.79,85.31 216.92,85.31 217.02,85.22 217.02,85.14 217.12,85.04 217.27,85.04 217.38,85.14 217.38,85.29 217.24,85.43 217.24,85.6 217.36,85.72 217.54,85.72 v2(217.6,85.66)
  IN1 w0.114: v2(214.13,92.19) 213.6,92.72 209.99,92.72 209.42,92.15 208.4,92.15 207.25,90.99 205.21,90.99 v2(204.76,91.45)
  IN3 w0.152: v2(218.15,97.6) 217.83,97.29 217,97.29 216.49,96.79 215.75,96.79 213.88,94.91 213.88,92.65 214.13,92.4 v2(214.13,92.19) 214.36,91.96 214.36,89.2 214.51,89.05 214.51,88.07 215.96,86.63 216.64,86.63 v2(217.6,85.66)
  BOTTOM w0.102: VRAM3.R7 216.55,98.44 216.8,98.44 216.92,98.33 216.92,97.84 217.27,97.49 217.53,97.49 217.71,97.67 218.08,97.67 v2(218.15,97.6) ; v2(217.6,85.66) 218,85.66 218.32,85.97 218.65,85.97 219.51,85.11 VRAM4.R7
  BOTTOM w0.127: v2(204.76,91.45) 204.24,90.94 203.65,90.94 U13.K26
VMA_CMD24: length 59.1
  TOP w0.102: v2(218.75,96.7) 218.17,96.13 216.67,96.13 215.93,96.87 215.93,98.88 215.51,99.3 VRAM1.P2 ; 203.21,90.61 200.91,90.61 v2(200.46,90.16) ; VRAM2.P2 220.17,83.87 220.17,83.7 220.27,83.59 220.49,83.59 220.64,83.44 220.77,83.44 220.92,83.59 220.92,83.72 220.78,83.87 220.78,84.17 220.89,84.28 220.89,84.42 220.74,84.57 220.59,84.57 220.45,84.42 220.09,84.42 219.93,84.59 219.93,84.96 219.68,85.2 219.37,85.2 219.16,85.4 219.16,85.8 219.28,85.92 219.28,86.28 219.12,86.44 v2(218.88,86.44)
  TOP w0.127: 203.21,90.61 203.36,90.61 203.59,90.84 205.62,90.84 205.82,91.05 207.7,91.05 v1(208.07,91.41) 208.43,91.77 216.09,91.77 216.76,92.44 218.24,92.44 218.75,92.95 v2(219.85,92.95)
  IN3 w0.152: v2(218.75,96.7) 218.67,96.63 218.38,96.63 218.27,96.73 218.27,97.01 218.4,97.14 218.5,97.14 218.73,97.37 219.12,97.37 219.39,97.1 219.39,96.59 219.85,96.14 v2(219.85,92.95) 219.85,87.3 219.2,86.65 219.1,86.65 v2(218.88,86.44)
  BOTTOM w0.102: VRAM3.P2 220.32,99.85 220.42,99.95 220.65,99.95 220.75,99.85 220.75,99.37 220.97,99.15 220.97,99 220.81,98.84 220.67,98.84 220.37,99.14 220.04,99.14 219.91,99.01 219.91,98.45 219.75,98.29 219.42,98.29 219.18,98.05 219.18,97.13 v2(218.75,96.7) ; v2(218.88,86.44) 218.88,86.78 218.67,86.99 216.99,86.99 215.89,85.89 215.89,84.62 215.73,84.45 215.52,84.45 215.42,84.35 215.42,84.11 VRAM4.P2
  BOTTOM w0.127: U13.K22 200.06,90.56 v2(200.46,90.16)
VMA_CMD25: length 48.3
  TOP w0.102: v2(217.87,85.09) 218.81,85.09 219.06,84.83 219.06,84.64 219.31,84.4 219.66,84.4 219.92,84.14 219.92,83.13 220.02,83.03 220.13,83.03 VRAM2.N2 ; VRAM1.N2 215.34,100.27 215.24,100.17 215.24,99.94 215.34,99.84 215.61,99.84 215.9,99.55 215.9,99.42 216.23,99.09 216.39,99.09 216.89,98.58 216.89,98 217,97.89 217.28,97.89 217.38,98 v2(217.38,98.09) ; 202.98,89.43 202.49,88.93 201.72,88.93 v2(201.3,89.36)
  TOP w0.127: v2(213.88,91.22) 212.48,89.83 v1(207.02,89.83) 204.11,89.83 203.71,89.43 202.98,89.43
  IN3 w0.152: v2(217.38,98.09) 217.15,98.09 216.3,97.24 215.56,97.24 213.42,95.1 213.42,92.25 213.83,91.85 213.83,91.27 v2(213.88,91.22) 213.9,91.2 213.9,89.02 214.05,88.86 214.05,87.88 215.82,86.12 216.49,86.12 217.52,85.09 v2(217.87,85.09)
  BOTTOM w0.102: v2(217.38,98.09) 217.9,98.09 218.37,98.57 218.92,98.57 219.43,99.09 219.6,99.09 219.89,99.38 219.89,99.85 VRAM3.N2 ; v2(217.87,85.09) 217.68,84.89 216.88,84.89 216.38,84.39 216.08,84.39 215.85,84.16 215.85,83.72 215.74,83.61 215.32,83.61 215.22,83.51 215.22,83.32 215.32,83.21 VRAM4.N2
  BOTTOM w0.127: U13.J23 200.9,89.76 v2(201.3,89.36)
VMA_CMD26: length 47.1
  TOP w0.102: v2(218.19,82.58) 218.19,82.34 218.27,82.27 218.47,82.27 218.57,82.37 218.57,82.42 218.66,82.51 218.99,82.51 219.08,82.42 219.08,82.34 218.98,82.25 218.98,82.15 219.06,82.07 219.22,82.07 219.31,82.16 219.44,82.16 219.51,82.24 VRAM2.M3 ; VRAM1.M3 216.92,101.07 217.06,100.93 217.31,100.68 218.09,100.68 v2(218.44,101.04)
  IN3 w0.102: v2(218.19,82.58) 217.88,82.9 215.97,82.9 215.88,82.99 ; v2(218.44,101.04) 218.34,101.04 217.91,100.61 217.37,100.61 217.29,100.53 216.52,100.53
  IN3 w0.152: 216.52,100.53 215.67,100.53 215.19,100.04 214.37,100.04 212.53,98.19 212.53,97.3 211.21,95.98 v2(211.21,92.21) 211.21,88.75 211.62,88.34 211.62,87.08 211.96,86.74 213.56,85.14 213.73,85.14 215.88,82.99
  BOTTOM w0.102: VRAM3.M3 219.36,101.23 219.26,101.23 219.18,101.15 219.18,100.93 219.24,100.87 219.24,100.76 219.17,100.69 218.97,100.69 218.87,100.78 218.87,101.2 218.77,101.3 218.55,101.3 218.44,101.2 v2(218.44,101.04) ; v2(218.19,82.58) 218.19,82.82 218.09,82.93 217.65,82.93 217.55,82.83 217.02,82.83 216.94,82.9 216.77,82.9 216.32,82.45 VRAM4.M3
  BOTTOM w0.127: v2(211.21,92.21) 211.11,92.11 v1(210.16,92.11) 209.33,92.11 206.61,89.39 204.06,89.39 204.05,89.4 203.54,89.4 203.53,89.39 202.88,89.39 U13.J25
VMA_CMD27: length 48.1
  TOP w0.102: v2(217.84,84.22) 217.79,84.22 217.38,84.63 217.01,84.63 216.77,84.39 216.77,84 216.44,83.66 216.22,83.66 215.93,83.37 215.93,83.15 215.83,83.05 215.68,83.05 VRAM2.N8 ; v2(217.2,99.14) 217.32,99.14 217.7,99.52 218.63,99.52 219.03,99.92 219.96,99.92 VRAM1.N8
  IN1 w0.114: v2(212.4,91.3) 211.53,90.42 210.04,90.42 209.03,89.42 202.18,89.42 v2(202.1,89.34)
  IN3 w0.152: v2(217.84,84.22) 217.4,83.78 216.41,83.78 214.12,86.07 213.93,86.07 212.53,87.46 212.53,88.72 212.4,88.85 v2(212.4,91.3) 212.4,91.54 212.2,91.75 212.2,95.68 213.44,96.92 213.44,97.3 213.44,97.37 213.97,97.89 214.41,97.89 215.16,98.63 215.29,98.63 215.8,99.14 v2(217.2,99.14)
  BOTTOM w0.102: v2(217.2,99.14) 217.19,99.15 217.13,99.15 216.39,99.89 216.23,99.89 216.08,99.74 215.94,99.74 215.78,99.89 215.78,100.04 215.98,100.24 215.98,100.64 215.88,100.74 215.62,100.74 215.51,100.64 VRAM3.N8 ; v2(217.84,84.22) 218.01,84.22 218.63,83.6 219.75,83.6 219.92,83.43 219.92,82.98 220.02,82.87 220.21,82.87 220.32,82.98 VRAM4.N8
  BOTTOM w0.127: U13.J24 201.7,89.74 v2(202.1,89.34)
VMA_CMD28: length 51
  TOP w0.102: v2(217.74,83.34) 217.63,83.34 217.46,83.5 217.46,83.68 217.33,83.81 216.88,83.81 216.59,83.53 216.59,83.4 216.67,83.32 216.67,83.13 216.58,83.04 216.49,83.04 VRAM2.N7 ; VRAM1.N7 219.79,100.27 219.89,100.37 219.89,100.56 219.79,100.66 218.82,100.66 218.44,100.29 v2(218.44,100.02)
  IN3 w0.152: v2(217.74,83.34) 217.95,83.34 218.36,83.74 218.9,83.74 220.9,85.74 220.9,86.41 221.22,86.73 221.22,92.59 v2(221.34,92.72) 221.22,92.85 221.22,93.36 221.37,93.52 221.52,93.52 221.67,93.67 221.67,93.97 221.52,94.13 221.37,94.13 221.22,94.28 221.22,94.58 221.37,94.74 221.52,94.74 221.67,94.89 221.67,95.19 221.52,95.34 221.37,95.34 221.22,95.5 221.22,95.8 221.37,95.95 221.52,95.95 221.67,96.11 221.67,96.41 221.52,96.56 221.37,96.56 221.22,96.72 221.22,97.4 218.59,100.02 v2(218.44,100.02)
  BOTTOM w0.102: v2(217.74,83.34) 218.02,83.34 218.73,82.62 219,82.62 219.13,82.75 219.36,82.75 219.51,82.91 VRAM4.N7 ; VRAM3.N7 216.92,99.66 217.98,99.66 218.33,100.02 v2(218.44,100.02)
  BOTTOM w0.127: U13.K27 205.15,90.58 205.93,91.36 205.93,91.93 207.83,93.84 v1(208.14,93.84) 220.23,93.84 v2(221.34,92.72)
VMA_CMD29: length 48.2
  TOP w0.102: v2(216.94,82.41) 216.94,82.11 216.78,81.95 216.27,81.95 216.03,82.19 215.88,82.19 215.72,82.03 215.72,81.89 215.88,81.73 215.88,81.53 215.98,81.43 216.13,81.43 VRAM2.L7 ; v2(217.36,102.18) 217.27,102.18 217.17,102.08 217.17,101.9 217.31,101.76 217.6,101.76 217.64,101.72 219.37,101.72 VRAM1.L7
  IN1 w0.114: v2(210.27,91.15) 209.74,91.15 208.73,90.14 202.96,90.14 v2(202.91,90.19)
  IN3 w0.152: v2(217.36,102.18) 216.54,101.36 213.9,101.36 213.11,100.57 213.11,99.86 211.77,98.51 211.77,98.21 210.45,96.89 210.45,91.72 210.27,91.55 v2(210.27,91.15) 210.27,87.34 215.45,82.16 216.69,82.16 v2(216.94,82.41)
  BOTTOM w0.102: v2(216.94,82.41) 217.45,81.9 219.23,81.9 VRAM4.L7 ; v2(217.36,102.18) 216.84,102.18 216.74,102.08 216.74,101.53 216.64,101.42 215.98,101.42 215.88,101.53 215.88,101.77 215.98,101.87 VRAM3.L7
  BOTTOM w0.127: U13.K25 202.52,90.58 v2(202.91,90.19)
VMA_CMD30: length 50.6
  TOP w0.102: VRAM2.J3 219.31,79.81 219.03,79.81 218.9,79.93 218.9,80.06 218.77,80.18 218.57,80.18 218.27,79.88 218.02,79.88 217.89,80 v2(217.89,80.41) ; v2(218.12,103.2) 218.12,103.49 217.54,104.07 216.94,104.07 216.35,103.47 VRAM1.J3
  IN3 w0.152: v2(218.12,103.2) 218.12,102.93 217.94,102.75 216.97,102.75 216.34,102.12 213.59,102.12 212.35,100.89 212.35,100.17 209.69,97.5 209.69,93.1 v2(209.43,92.85) 209.51,92.77 209.51,85.94 211.22,84.23 211.63,84.23 213.8,82.05 214.48,82.05 215.14,81.39 216.34,81.39 216.7,81.04 217.36,81.04 217.89,80.5 v2(217.89,80.41)
  BOTTOM w0.102: VRAM3.J3 219.51,103.64 219.26,103.9 218.09,103.9 217.91,103.72 217.91,103.41 v2(218.12,103.2) ; VRAM4.J3 216.32,79.9 216.82,79.4 217.22,79.4 217.89,80.07 v2(217.89,80.41)
  BOTTOM w0.127: v2(209.43,92.85) 209.02,92.85 v1(208.76,92.58) 206.42,90.24 205.91,90.24 205.6,89.93 204.25,89.93 U13.J27
VMA_CMD31: length 5.2
  BOTTOM w0.102: TP62.1 207.36,92.23 205.34,90.2 203.72,90.2 U13.J26
VMA_DM0: length 34
  TOP w0.102: VRAM2.D3 219.12,76.41 v2(219.01,76.41)
  IN1 w0.114: v2(219.01,76.41) 218.96,76.36 218.7,76.36 218.43,76.09 218.43,72.59 217.18,71.33 211.18,71.33 211.06,71.46 211.06,72.17 209.2,74.03 209.01,74.03 208.61,73.62 208.46,73.62 199.37,82.71 199.37,83.12 197.27,85.22 v2(197.11,85.22)
  BOTTOM w0.127: v2(197.11,85.22) 197.49,85.6 U13.D19
VMA_DM1: length 41.4
  TOP w0.102: VRAM2.E7 216.24,76.81 215.98,77.08 215.98,77.75 216.18,77.95 216.47,77.95 217.46,76.95 217.46,73.59 216.25,72.38 214.37,72.38 213.47,73.27 ; v2(193.81,86.04) 194,86.04 195.05,85 195.05,84.24 195.29,83.99 195.63,83.99 195.66,84.03 196.2,84.03 196.45,83.78 196.45,83.27 196.81,82.92 198.85,82.92 198.87,82.89
  TOP w0.127: 198.87,82.89 199.84,81.93 204.43,81.93 205.85,80.5 206.03,80.5 206.39,80.85 206.57,80.85 206.75,80.67 206.75,80.49 206.39,80.14 206.39,79.96 206.57,79.78 206.75,79.78 207.04,80.07 207.22,80.07 207.4,79.89 207.4,79.71 207.11,79.42 207.11,79.24 207.27,79.08 v1(207.91,79.08) 208.67,79.08 209.62,78.13 211.17,78.13 211.56,77.74 211.56,75.91 213.19,74.28 213.19,73.55 213.47,73.27
  BOTTOM w0.127: U13.D14 193.42,85.6 193.81,85.99 v2(193.81,86.04)
VMA_DM2: length 34.6
  IN3 w0.102: 197.72,81.13 197.51,81.13 196.25,82.38 196.25,83.61 v2(195.46,84.4)
  IN3 w0.152: 197.72,81.13 203.17,81.13 203.57,80.72 203.79,80.72 204.18,81.12 204.4,81.12 204.61,80.9 204.61,80.69 204.22,80.29 204.22,80.08 204.44,79.86 204.65,79.86 205.04,80.26 205.26,80.26 205.48,80.04 205.48,79.82 205.08,79.43 205.08,79.22 205.37,78.93 205.59,78.93 205.74,79.08 205.96,79.08 206.17,78.86 206.17,78.65 206.02,78.49 206.02,78.28 211.45,72.85 213.51,72.85 213.93,72.43 215.76,72.43 216.38,73.05 216.38,75.56 v2(216.85,76.03)
  BOTTOM w0.127: VRAM4.D3 216.83,76.02 v2(216.85,76.03) ; v2(195.46,84.4) 195.86,84.8 U13.C17
VMA_DM3: length 38.1
  BOTTOM w0.127: U13.C22 199.58,84.38 199.58,83.11 200.21,82.47 200.21,82.41 201.68,80.94 202.12,80.94 208.09,74.97 v1(209.3,74.97) 209.61,74.97 210.8,73.77 211.18,73.77 211.31,73.9 211.31,74.64 211.44,74.76 211.69,74.76 211.82,74.64 211.82,73.27 211.94,73.14 212.2,73.14 212.32,73.27 212.32,74.66 212.45,74.79 212.66,74.79 212.78,74.66 212.78,73.04 213.6,72.22 217.28,72.22 218.17,73.11 218.17,77.33 218.88,78.04 219.59,78.04 219.95,77.68 219.95,77.25 VRAM4.E7
VMA_DM4: length 40.9
  TOP w0.102: 204.53,94.22 204.02,93.71 202.09,93.71 201.48,94.32 v2(201.3,94.32)
  TOP w0.127: VRAM1.D3 216.32,107.22 216.44,107.1 216.62,107.1 216.99,107.47 217.2,107.47 217.57,107.85 217.57,109.67 217.43,109.82 217,109.82 216.87,109.94 216.87,110.82 215.84,111.85 212.02,111.85 211.64,111.47 211.64,110.58 211.29,110.22 210.42,110.22 208.64,108.44 208.46,108.44 208.34,108.57 208.16,108.57 207.98,108.39 207.98,108.21 208.1,108.08 208.1,107.91 207.96,107.76 207.96,101.25 207.73,101.02 207.73,100.73 207.96,100.5 207.96,98.84 207.83,98.72 v1(207.4,98.72) 207.12,98.72 206.99,98.59 206.99,98.25 207.12,98.12 207.78,98.12 207.91,98 207.91,97.74 207.78,97.61 207.12,97.61 206.99,97.49 206.99,97.23 207.12,97.11 207.78,97.11 207.91,96.98 207.91,96.73 207.78,96.6 207.12,96.6 206.99,96.47 206.99,95.81 205.73,94.55 205.25,94.55 204.92,94.22 204.53,94.22
  BOTTOM w0.127: v2(201.3,94.32) 201.3,94.3 U13.P24
VMA_DM5: length 34.9
  TOP w0.152: VRAM1.E7 219.51,106.86 218.7,107.67 217.9,107.67 v2(217.2,106.97)
  IN1 w0.114: v2(217.2,106.97) 217.2,107.75 216.17,108.78 216.17,110.45 214.95,111.67 211.72,111.67 207.42,107.38 207.42,104.83 206.08,103.48 206.08,101.92 205.58,101.42 205.58,101.22 205.72,101.08 205.72,100.9 205.56,100.74 205.38,100.74 204.97,101.14 204.79,101.14 204.64,100.99 204.64,100.81 205.05,100.4 205.05,100.23 204.9,100.08 204.72,100.08 204.1,100.7 203.92,100.7 203.78,100.56 203.78,100.38 204.36,99.8 204.36,99.62 204.22,99.47 204.04,99.47 203.66,99.85 203.5,99.85 203.34,99.69 203.34,99.53 203.52,99.34 203.52,99.18 203.36,99.02 203.2,99.02 203.02,99.2 202.86,99.2 v2(202.09,98.44)
  BOTTOM w0.127: v2(202.09,98.44) 201.7,98.04 U13.W24
VMA_DM6: length 35.1
  BOTTOM w0.102: U13.AA25 202.5,99.91 202.85,100.27 202.85,100.75 203.06,100.95 203.44,100.95 203.64,101.15 204.99,101.15
  BOTTOM w0.127: 204.99,101.15 206.43,102.6 206.43,104.73 208.75,107.04 208.75,112.36 v1(209.99,113.6) 210.14,113.75 217.76,113.75 217.9,113.61 217.9,112.33 218.08,112.15 218.45,112.15 218.55,112.05 218.55,111.76 218.42,111.64 218.14,111.64 218.04,111.54 218.04,111.24 218.15,111.13 218.42,111.13 218.55,111 218.55,110.75 218.42,110.62 218.19,110.62 218.04,110.47 218.04,110.26 218.19,110.11 218.42,110.11 218.55,109.99 218.55,108.89 219.12,108.32 219.12,108.01 219.24,107.89 219.69,107.89 219.79,107.78 219.79,107.63 219.64,107.47 VRAM3.D3
VMA_DM7: length 32.9
  IN3 w0.102: v2(218.44,107.24) 218.44,107.64 217.84,108.24 216.62,108.24 215.89,108.97 213.56,108.97 213.47,108.88 213.09,108.88 ; 204.33,97.11 204.22,97.22 203.34,97.22 202.92,96.8 v2(202.92,96.78)
  IN3 w0.152: 213.09,108.88 212.96,108.88 212.63,109.21 212.12,109.21 211.95,109.03 211.95,108.82 212.39,108.38 212.39,108.2 212.14,107.95 211.96,107.95 211.52,108.39 211.31,108.39 211.09,108.17 211.09,107.96 211.34,107.7 211.34,107.49 211.13,107.27 210.91,107.27 210.66,107.53 210.44,107.53 207.93,105.02 207.93,102.17 207.59,101.83 206.22,101.83 206.09,101.7 206.09,101.38 206.22,101.26 206.61,101.26 206.74,101.13 206.74,100.8 206.61,100.67 205.75,100.67 205.53,100.46 205.53,97.53 205.11,97.11 204.33,97.11
  BOTTOM w0.127: v2(218.44,107.24) 218.44,107.36 218.14,107.66 217,107.66 216.75,107.4 216.75,107.1 VRAM3.E7 ; v2(202.92,96.78) 202.52,96.38 U13.U25
VMA_DQ0: length 36.6
  TOP w0.127: VRAM2.A3 219.51,73.06 v2(218.98,72.53)
  IN1 w0.102: 198.69,83.04 197.67,84.06 197.67,84.52 197.37,84.82 196.81,84.82 196.63,85
  IN1 w0.114: v2(197.12,86.01) 197.12,85.98 196.63,85.49 196.63,85 ; v2(218.98,72.53) 217.37,70.92 210.51,70.92 210.2,71.23 210.2,71.39 210.64,71.82 210.64,71.98 210.47,72.15 210.31,72.15 209.88,71.71 209.72,71.71 209.55,71.87 209.55,72.03 209.99,72.47 209.99,72.63 209.83,72.79 209.67,72.79 209.23,72.36 209.07,72.36 208.91,72.52 208.91,72.68 209.34,73.12 209.34,73.28 209.18,73.44 209.02,73.44 208.58,73 208.42,73 198.94,82.49 198.94,82.79 198.69,83.04
  BOTTOM w0.127: v2(197.12,86.01) 196.73,86.4 U13.E18
