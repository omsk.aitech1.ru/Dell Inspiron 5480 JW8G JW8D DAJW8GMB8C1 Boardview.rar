# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_ALW_AVCC: length 7.7
  BOTTOM w0.102: L23.1 240.64,42.03 240.55,42.12 v1(239.15,42.12)
  BOTTOM w0.203: 237.2,40.89 237.14,40.83 236.56,40.83 236.42,40.69 U23.74
  BOTTOM w0.508: 237.2,40.89 237.42,41.11 237.96,41.11 238.18,40.89 C491.2 240.01,40.89 L23.1
+3.3V_AUDIO: length 56.3
  TOP w0.102: PR73.2 277.91,34.73 v1(278.24,34.4)
  TOP w0.254: R277.1 291.41,24.61 v2(292.03,23.99) ; v2(261.78,44.39) 261.6,44.56 Q20.2
  TOP w0.279: 257.77,44.56 Q20.5
  TOP w0.305: C327.2 299.44,32.24 299.7,32.5 300.67,32.5 301.05,32.88 301.61,32.88 302.01,33.28 U10.9
  TOP w0.508: 257.77,44.56 257.48,44.85 v2(257.48,45.08) ; v2(276.44,33.69) 276.44,34 276.54,34.1 PR73.2 ; C327.2 298.28,31.99 C330.1 298.13,31.84 298.13,31.73 298.12,31.73 297.76,31.38 v2(297.76,31) ; v2(262.03,42.02) R171.1 ; R173.1 v2(262.03,43.17)
  IN1 w0.508: v2(297.76,31) 297.76,29.37 296.65,28.26 295.36,28.26 294.66,27.56 294.66,25.47 293.18,23.99 v2(292.03,23.99)
  IN2 w0.508: 270.47,39.2 270.57,39.1 273.64,39.1 274.05,38.7 274.05,36.03 276.39,33.69 v2(276.44,33.69) ; v2(262.03,43.17) v2(262.03,42.02)
  IN3 w0.508: v2(276.44,33.69) 276.44,33.08 276.84,32.68 280.88,32.68 282.75,30.8 282.75,30.26 282.8,30.21 286.49,26.52 289.02,23.99 v2(292.03,23.99)
  vias: v2(269.83,38.29) v2(270.52,38.26)
+3.3V_AUX: length 31.5
  TOP w0.254: R500.1 89.76,28.7 v2(90.28,28.18) ; v3(81.01,33.39) 80.74,33.66 R225.2
  TOP w0.508: R236.2 64.62,32.38 65.4,31.6 C333.1 ; R197.2 66.69,36.78 v2(66.78,36.69) 67.22,37.12 68.11,37.12 68.56,37.58 Q21.2 ; v2(65.13,39.36) 65.9,40.12 66.53,40.12 67.41,41 C265.1 66.91,41.52 v2(66.78,41.39)
  BOTTOM w0.305: 69.08,43.29 69.17,43.2 CN14.72 ; CN14.74 69.49,43.7
  BOTTOM w0.508: v2(65.13,39.36) 66.78,37.71 v2(66.78,36.69) ; v3(81.77,33.39) 82.14,33.02 82.14,32.64 C537.2 84.29,32.26 86.6,29.96 88.5,29.96 v2(90.28,28.18)
  vias: v1(69.02,30.21) v2(69.83,25.64) v2(70.47,25.64) v3(66.4,30.85) v3(67.17,30.85) v3(67.93,30.85) v3(81.01,34.15) v3(81.77,34.15)
+3.3V_EC: length 26.5
  TOP w0.508: v2(221.83,41.79) 221.5,41.46 C256.1 ; C250.1 228.59,43.33 228.38,43.55 v2(228.38,43.78)
  IN2 w0.508: v2(242.65,40.8) 241.13,42.33 235.21,42.33 234.37,41.49 ; 228.53,41.87 228.56,41.9 228.38,42.07 v2(228.38,43.78)
  BOTTOM w0.203: U23.127 221.89,31.09 222.51,31.71 v2(222.77,31.71) ; U23.114 227.09,31.64 ; 233.87,33.49 U23.92 ; U23.26 221.73,41.89 v2(221.83,41.79) ; 228.29,44.53 U23.50
  BOTTOM w0.508: v2(242.65,40.8) 241.94,41.52 L23.2 ; v2(232.57,32.75) 233.3,33.49 233.87,33.49 ; v2(228.38,43.78) 228.38,44.44 228.29,44.53
  vias: v1(232.34,33.97) v2(211.34,32.65) v2(211.97,32.65) v2(224.04,31.69) v2(227.08,31.75) v2(230.31,31.79) v2(230.97,31.79) v2(232.32,36.28) v2(232.98,36.28)
+3.3V_EN2: length 108.8
  TOP w0.102: v2(186.16,33.92) 185.96,34.12 185.96,36.38 v1(185.29,37.06) 184.67,37.68 184.67,44.72 R162.2 R160.2 R157.2 ; PQ12.2 121.96,30.91 120.66,29.61 116.87,29.61 115.68,30.8 115.68,32.75 116.14,33.21 117.94,33.21 119.7,34.96 137.3,34.96 138.45,33.81 146.18,33.81 146.9,33.09 146.9,29.84 146.77,29.71 146.77,28.01 147.02,27.76 147.39,27.39 153.31,27.39 153.92,28.01 154.16,28.25 154.16,29.96 158.02,33.82 164.46,33.82 166.19,35.55 175.45,35.55 177.27,33.72 178.6,33.72 179.38,32.93 183.19,32.93 v2(183.4,33.13)
  IN2 w0.114: v2(183.4,33.13) 185.17,33.13 185.96,33.92 v2(186.16,33.92)
+3.3V_RTC_LDO: length 219.8
  TOP w0.102: PR90.1 140.95,28.71 v1(140.39,28.15)
  TOP w0.254: PU4.8 126.87,28.84 126.63,28.6 PC60.1
  TOP w0.508: v2(25.23,7.83) 24.16,8.9 20.81,8.9 20.58,9.13 17.31,9.13 RTCD1.2 ; PC60.1 125.49,28.94 125.79,29.25 v2(126.35,29.25) ; R282.2 R280.2 184.85,20.42 v2(184.59,20.69) ; v2(120.33,31.46) 120.67,31.8 PR78.2 ; PR90.1 PR91.2 142.96,28.71 143.81,29.56 143.81,30.17 v2(143.8,30.19)
  IN1 w0.508: v2(184.59,20.69) 184.31,20.69 181.94,23.06 181.94,27.95 182.49,28.5 182.49,29.88 179.8,32.56 163.47,32.56 162.47,31.56 156.98,31.56 155.15,29.73 155.15,27.93 154.29,27.06 147.4,27.06 145.22,29.25 144.74,29.25 v2(143.8,30.19)
  IN3 w0.508: 27.36,8.72 26.12,8.72 v2(25.23,7.83) ; 27.12,11 33.73,11 34.43,11.7 34.43,16.42 35,16.99 65.18,16.99 65.54,17.35 65.54,18.07 v2(65.06,18.55)
  BOTTOM w0.508: v2(143.8,30.19) 141.92,32.07 138.87,32.07 137.78,33.16 129.35,33.16 128.43,32.24 128.43,31.35 126.35,29.27 v2(126.35,29.25) 124.87,29.25 122.66,31.46 v2(120.33,31.46) 119.46,30.59 117.46,30.59 117.08,30.97 117.08,31.61 116.57,32.12 114.92,32.12 111.63,35.41 106.15,35.41 106.15,35.39 99.09,28.33 99.09,23.84 95.39,20.13 74.9,20.13 73.82,19.05 65.55,19.05 v2(65.06,18.55)
+3.3V_RUN: length 429.3
  TOP w0.178: U2.11 313.42,80.86 v2(313.57,80.71)
  TOP w0.198: U2.37 306.96,82.06
  TOP w0.203: 306.96,82.06 v2(306.51,82.51)
  TOP w0.254: U25.36 v2(259.06,34.61) 259.06,36.82 R508.2 260.28,36.86 262.16,36.86 262.79,36.23 263.22,36.23 R238.1 262.36,34.95 R513.1 ; PR36.1 232.9,57.94 232.9,57.95 232.88,57.97 v2(232.88,58.08) ; U25.12 250.52,29.11 ; U25.32 258.95,32.61 v2(259.09,32.75) ; U25.1 250.98,34.61 250.71,34.89 250.71,35.37 ; R444.2 295.35,40.12 293.23,40.12 291.74,38.63 290.42,38.63 288.77,36.98 288.77,36.78 v2(288.72,36.73) ; U25.25 258.78,29.11 v2(259.24,29.58) ; R505.1 261.87,29.56 261.59,29.29 260.4,29.29 v2(259.99,29.69) ; U25.6 v2(250.43,32.11) ; R507.2 245.16,33.35 245.45,33.64 246.29,33.64 246.93,33 R509.2 247.25,32.73 v2(247.63,32.35)
  TOP w0.305: RP2.2 152.57,109.4 v2(152.69,109.53) ; v2(153.34,109.52) 153.22,109.39 RP2.4
  TOP w0.381: PR58.2 235.17,47.61 235.17,47.64 v2(235.72,48.2) ; v2(105.06,119.95) 105.01,120 105.01,122.59 105.29,122.87 106.38,122.87 107.17,122.08 111.31,122.08 112.48,120.92 112.48,119.82 112.25,119.59 112.25,118.74 111.66,118.15 109.81,118.15 v2(108.16,116.5)
  TOP w0.457: v2(167.21,96.35) 166.64,96.35 R43.2 R40.2 ; R9.1 118.98,114.55 119.36,114.17 v2(119.49,114.17)
  TOP w0.508: 175.07,109.51 175.07,111.09 176.74,112.76 180.15,112.76 181.64,114.26 181.64,125.16 R3.2 ; v2(247.19,28.88) 247.58,28.49 C535.1 248.25,28.3 248.38,28.43 R518.2 249.83,28.43 250.52,29.11 ; C115.2 154.97,91.3 v2(155.73,92.07) ; v2(194.8,26.3) 194.84,26.27 R269.2 ; R42.2 R45.2 R48.2 ; R274.2 207.18,24.87 v2(206.99,25.06) ; v2(108.16,116.5) 108.16,114.84 108.55,114.45 112.63,114.45 112.85,114.24 115.73,114.24 116.47,114.97 v2(116.47,115.89) ; v2(316.47,85.23) 316.47,84.06 R79.1 ; v2(152.33,95.23) 151.49,94.39 C91.2 ; v2(167.27,93.97) 167.27,93.79 166.81,93.33 R53.2 ; v2(167.27,93.97) 166.89,94.35 R51.2 ; v2(167.27,93.97) 167.34,93.89 169.63,93.89 170.11,94.37 170.8,94.37 171.05,94.12 172.3,94.12 172.71,94.53 R48.2 ; v2(69.43,31.18) Q23.2 ; 173.92,109.87 173.08,110.7 R8.2 R7.2 ; R48.2 173.13,94.73 173.36,94.96 v2(173.36,95.19) ; v2(275.65,35.47) 276.39,36.21 PR73.1 ; R39.2 R36.2 ; v2(176.97,73.57) 176.67,73.57 176.23,73.14 C193.2 ; v2(316.34,81.04) 316.31,81.01 R91.1 R87.1 ; C217.1 175.87,47.22 175.4,46.75 175.4,41.97 v2(177.2,40.17) 176.08,39.05 176.08,36.64 176.55,36.17 R203.2 ; C217.1 177.4,46.52 v2(177.61,46.32) 177.61,45.64 R165.2 ; C217.1 178.2,47.22 C218.1 ; v2(218.3,35.77) 218.3,34.15 217.86,33.72 217.86,32.47 v2(217.05,31.66) ; R205.2 184.39,35.55 v2(184.39,35.55) ; 250.71,35.37 250.23,35.84 C534.1 v2(248.67,35.11)
  IN1 w0.508: v2(189.04,30.59) 188.27,30.59 184.49,34.38 184.49,35.44 v2(184.39,35.55) 183.52,36.41 179.89,36.41 179.13,37.17 179.13,39 177.96,40.17 v2(177.2,40.17) ; v2(313.04,79.06) 312.02,78.04 307.93,78.04 306.51,79.46 v2(305.93,79.46) ; v2(316.47,85.23) 315.93,85.23 313.6,87.57 309.25,87.57 v2(308.72,87.03)
  IN1 w1.016: 155.48,112.84 156.35,112.84 157.74,111.44 164.09,111.44 165.13,112.48 168.34,112.48 171.13,109.69 173.26,109.69 174.3,108.65
  IN2 w0.508: v2(93.07,50.25) 93.07,39.49 96.48,36.08 v2(96.48,35.37) ; v2(232.88,58.08) 232.88,57.72 233.54,57.06 234.65,57.06 235.24,56.48 237.53,56.48 238.03,55.98 239.87,55.98 241.05,54.8 241.05,50.58 239.84,49.36 236.89,49.36 v2(235.72,48.2)
  IN2 w1.524: 49.51,44.33 49.46,44.39 49.46,46.39 44.92,50.94 39.76,50.94 31.4,59.3 31.4,61.45 23.71,69.15 23.71,77.38 21.89,79.2 21.89,83.49 24.01,85.61 24.01,88.76 23.22,89.55 22.33,89.55 21.7,90.18 21.7,93.71
  IN3 w0.457: v2(165.23,92.04) 165.52,92.04 167.24,93.75 167.24,93.94 v2(167.27,93.97)
  IN3 w0.508: 150.76,113.22 130.67,113.22 129.13,111.68 126.39,111.68 124.71,113.37 124.71,113.38 124.35,113.74 124.34,113.74 124.32,113.75 123.66,113.75 122.84,112.94 120.81,112.94 119.58,114.17 v2(119.49,114.17) 118.64,114.17 117.53,115.28 117.08,115.28 v2(116.47,115.89) 116.29,116.06 116.29,117.59 116.92,118.22 v2(117.46,118.22)
  IN3 w1.016: 150.76,113.22 151.04,112.94
  BOTTOM w0.102: RP22.4 171.57,85.62 171.33,85.38 v2(171.33,85.3)
  BOTTOM w0.178: v2(108.16,116.5) 108.3,116.36 PU9.21
  BOTTOM w0.203: v2(218.3,35.77) 218.55,35.77 218.66,35.89 U23.11
  BOTTOM w0.254: v2(272.27,31.41) 272.5,31.63 CN11.3 ; R435.2 288.27,47.03 289.09,46.21 289.09,45.68 289.62,45.15 289.62,43.27 289.26,42.91 288.22,42.91 287.92,43.22 v2(287.74,43.22) ; 155.56,91.6 155.56,91.6 155.73,91.78 v2(155.73,92.07) ; 155.56,91.6 U14.V8 ; 155.56,91.6 155.53,91.6 155.11,91.18 U14.W9 ; v2(288.72,36.73) 288.77,36.78 288.77,38.23 288.41,38.58 286.97,38.58 286.01,39.54 286.01,39.79 285.2,40.6 Q42.2 ; U14.K16 U14.K14 152.33,96.01 v2(152.33,95.23) ; v2(232.88,58.08) 233.02,57.93 PR181.1 ; R322.2 165.96,91.38 166.18,91.17 166.86,91.17 167.21,90.82 167.21,90.2 166.74,89.73 R331.2 ; Q34.5 v2(174.35,86.22) Q34.2 ; v2(273,31.43) CN11.4
  BOTTOM w0.305: v2(176.97,73.57) 176.82,73.57 176.24,73 U15.5
  BOTTOM w0.33: 166.28,98.03 164.71,98.03 R307.2
  BOTTOM w0.356: v2(177.61,46.32) 177.41,46.12 JDIM1.199
  BOTTOM w0.508: v2(253.09,42.02) 253.35,41.77 C486.1 254.48,41.2 253.76,40.48 CN8.1 ; v2(287.74,43.22) 286.8,43.22 286.11,42.53 286.11,41.52 285.25,40.65 Q42.2 284.51,40.65 283.78,41.39 R453.1 ; R370.1 313.82,80.11 313.62,79.92 C444.1 C442.1 313.27,81.01 v2(313.57,80.71) ; R370.1 315.29,80.11 316.21,81.04 v2(316.34,81.04) ; R370.1 314.18,79.41 313.83,79.06 v2(313.04,79.06) ; PR153.2 117.38,118.3 v2(117.46,118.22) ; R357.1 309.73,86.51 309.2,87.03 v2(308.72,87.03) ; v2(302.75,70.73) 303.25,70.23 R414.2 ; R399.2 177.57,73.57 v2(176.97,73.57) ; v2(105.06,119.95) 105.06,118.97 PR154.1 ; R384.2 305.67,77.02 305.31,77.38 305.31,78.52 305.53,78.73 R380.1 306.05,79.34 v2(305.93,79.46) ; R427.2 v2(93.07,50.25) ; R318.2 v2(167.27,93.97) ; v2(189.09,29.91) 189.02,29.84 R476.2
  vias: v1(238.21,28.48) v2(21.4,94.14) v2(21.57,94.78) v2(22.08,94.4) v2(64.35,28.03) v2(65.06,28.03) v2(174.23,97.85) v2(174.68,97.4) v2(175.4,108.67) v2(176.03,108.65) v2(189.72,30.49) v2(190.91,30.52) v2(192.08,47.29) v2(192.14,46.66) v2(192.72,46.39) v2(194.65,29.27) v2(238.06,30.26) v2(274.68,45.71) v2(275.32,45.71) v2(276.03,49.18) v2(275.95,45.71) v2(276.65,49.23) v2(277.27,49.29) v2(277.88,49.54) v3(48.8,42.33) v3(48.8,41.57) v3(49.28,42.89) v3(87.36,33.51) v3(87.36,32.75) v3(87.74,32.12) v3(88.12,33.51) v3(88.12,32.75) v3(88.5,32.12) v3(88.88,33.51) v3(88.88,32.75) v3(151.85,112.81) v3(152.57,112.81)
+3.3V_RUN_F:
  vias: v1(21.93,97.22) v2(22.89,97.4) v2(23.2,96.81) v2(23.58,97.37)
+3.3V_SUS: length 424.2
  TOP w0.254: 157.31,85.76 157.01,85.76 157.01,85.77 156.6,85.77 156.6,85.76 156.24,85.76 155.94,85.46 154.71,85.46 154.23,85.94 v2(154.08,85.94) v2(153.27,85.94) 152.71,85.38 152.15,85.38 151.9,85.63 151.37,85.63 150.68,84.95 150.68,81.32 148.24,78.88 146.49,78.88 145.69,78.07 C525.1
  TOP w0.305: C168.1 172.65,80.38 171.09,81.94 171.09,82.64 170.98,82.75 170.98,82.84 168.79,85.03 168.34,85.03 167.73,85.63 167.21,85.63 166.83,85.25 164.42,85.25 163.96,84.8 162.3,84.8 162.25,84.85 161.79,84.85 161.51,84.57 161.5,84.57 161.49,84.56 160.03,84.56 159.65,84.94 159.65,85.36 159.25,85.76 157.31,85.76
  TOP w0.457: R123.2 R122.2 R121.2
  TOP w0.508: 176.36,85.33 176.61,85.58 176.61,88.02 ; 176.36,85.33 175.83,85.33 175.29,84.79 175.29,84.63 R78.2 R77.2 R74.2 ; 176.36,85.33 176.61,85.08 176.61,83.22 175.85,82.46 ; v2(152.46,85.95) 152.46,85.97 152.26,86.17 152.26,87.23 C153.1 ; C128.1 148.85,89.32 v2(149.44,88.73) ; R125.2 R124.2 ; R124.2 161.78,71.62 162.03,71.37 R131.2 161.6,70.73 161.27,71.06 v2(161.02,71.06) 161.07,71.01 161.07,70.16 159.57,68.67 152.84,68.67 152.21,69.3 152.21,73.19 v2(153.27,74.26) ; R124.2 R123.2 ; v2(164.45,70.32) 167.09,70.32 170.06,73.29 v2(170.06,74.03) ; R69.2 R65.2 ; v2(168.5,91.83) 168.38,91.83 167.7,92.52 167.32,92.52 167,92.2 R56.1 ; v2(174.41,78.73) R102.2 ; v2(188.27,42.05) 188.49,42.27 PC36.2 189.32,42.17 189.32,40.57 PQ9.4 ; C108.1 152.9,91.8 153.55,91.15 153.55,90.92 153.75,90.71 v2(153.75,90.74) ; R146.1 117.21,56.26 v1(117.46,56.5) 117.97,56.5 121.22,53.25 158.05,53.25 162.49,57.69 162.49,63.69 164.8,66 164.8,66.51 164.3,67.02 163.69,67.02 v2(163.51,66.84) ; v2(201.43,33.01) 201.43,38.37 201.2,38.59 v2(201.2,40.2)
  IN1 w0.508: v2(163.3,112.38) 163.33,112.38 164.29,113.34 168.7,113.34 171.46,110.58 173.97,110.58 174.99,109.56 176.92,109.56 177.38,109.1 179.46,109.1 180.94,107.62 188.61,107.62 190.89,109.9 190.89,109.98 191.28,110.37 199.35,110.37 200.1,111.13 204.69,111.13 211.95,118.38 v2(211.95,120.72) ; v2(290.06,35.51) 290.03,35.51 287.4,32.88 286.47,32.88 285.73,32.14 285.73,27.09 285.15,26.5 285.15,24.93 v2(284.77,24.55)
  IN2 w0.508: v2(284.77,24.55) 284.46,24.24 266.78,24.24 264.66,26.36 263.17,26.36 262.21,27.32 257.18,27.32 256.32,28.18 249.64,28.18 248.89,27.43 245.08,27.43 242.78,25.13 240.24,25.13 234.73,19.62 232.27,19.62 v2(232.19,19.7) ; v2(163.3,112.38) 163.3,111.82 161.26,109.78 161.26,108.11 160.31,107.15 160.31,105.47 165.29,100.49 165.29,95.03 167.55,92.77 ; v2(163.51,66.84) 164.45,67.78 v2(164.45,70.32)
  IN2 w2.032: 169.12,72.53 169.12,63.82 178.75,54.19 178.75,51.62
  IN3 w0.508: v2(168.5,91.83) 168.49,91.82 168.49,90.47 165.62,87.6 v2(165.62,86.4) ; v2(200.74,23.28) 200.74,22.62 202.75,20.61 205.21,20.61 206.13,19.7 207.73,19.7 208.54,18.88 210.7,18.88 211.34,19.52 227.92,19.52 228.7,20.31 231.83,20.31 232.19,19.95 v2(232.19,19.7)
  BOTTOM w0.203: PR140.1 211.3,121.21 211.54,121.45 211.54,121.86 PR136.2
  BOTTOM w0.254: U14.AC9 U14.AA9 ; U14.AH11 153.35,85.94 v2(153.27,85.94) ; v2(154.08,85.94) 154.17,85.94 U14.AH10 ; U14.AE21 148.54,87.81 148.95,88.22 U14.AE20 ; v2(152.46,85.95) 152.15,86.26 U14.AH14
  BOTTOM w0.356: U14.AA9 154.74,90.16 154.73,90.17 154.47,90.17 154,90.64 153.83,90.64 153.75,90.71 v2(153.75,90.74)
  BOTTOM w0.508: v2(200.74,23.28) 202.83,23.28 203.54,23.99 203.54,24.67 202.75,25.46 201.46,25.46 199.8,27.11 199.8,32.6 200.21,33.01 v2(201.43,33.01) ; v2(170.06,74.03) 170.92,74.03 ; v2(153.27,74.26) 153.53,74.51 R396.1 ; v2(206.94,39) 206.71,39.23 R462.1 ; U14.AE20 148.97,88.22 149.44,88.68 v2(149.44,88.73) ; PR140.1 v2(211.95,120.72) ; 170.7,82.16 170.7,83.79 R358.2 R350.2 R344.2 ; v2(290.06,35.51) 290.1,35.55 290.1,35.65 291.33,36.88 291.33,38.74 R461.1 ; v2(161.02,71.06) 161.07,71.01 161.07,70.29 163.73,67.63 163.73,67.06 v2(163.51,66.84)
  vias: v2(153.68,90.08) v2(171.66,78.37) v2(172.37,89.04) v2(174.28,90.31) v2(174.35,81.37) v2(191.17,43.29) v3(168.18,94.6) v3(168.96,94.6)
+3.3V_TP_PWR:
  vias: v1(192.13,29.07)
+3V_GFX: length 90.7
  TOP w0.254: v2(188.55,69.33) 188.43,69.2 Q14.5
  TOP w0.508: v2(191.27,80.78) 190.88,80.39 R100.2 ; C163.1 C165.1
  IN1 w0.508: v2(188.87,71.82) 188.98,71.7 188.98,70.52 188.55,70.09 v2(188.55,69.33)
  IN1 w1.016: 216.37,116.9 214.89,116.9 212.99,115 210.97,115 205.4,109.43 202.65,109.43 197.98,104.76 196.63,104.76 194.06,107.33 192.46,107.33 188.86,103.72 187.74,103.72 187.05,103.03 187.05,100.14
  IN2 w0.508: v2(192.39,59.57) 192.21,59.76 189.52,59.76 189.09,59.32 188.5,59.32 187.69,60.13 187.69,64.98 188.81,66.1 188.81,68.24 188.55,68.49 v2(188.55,69.33)
  IN3 w0.508: v2(191.27,80.78) 191.27,80.66 190.41,79.79 187.79,79.79 187.16,79.16 187.16,75.63 187.84,74.94 188.83,74.94 v2(188.86,74.97)
  BOTTOM w0.508: R412.2 R413.2 189.22,71.35 188.87,71.7 v2(188.87,71.82) ; R362.2 R356.2 R349.2 R343.2 176.25,88.08 176.06,88.28 176.06,90.99 179.03,93.97 179.03,94.63 v2(180.58,96.18) ; PR179.1 192.48,59.57 v2(192.39,59.57) ; R94.2 179.79,80.12 180.65,80.99 180.73,80.99 v2(180.75,80.96)
  vias: v1(187.28,77) v2(184.31,78.32) v2(184.95,78.37) v2(187.61,99.15) v2(187.88,88.98) v2(188.03,100.11) v2(189.11,89.01) v2(191.37,88.99) v3(217.57,116.09) v3(218.3,116.09)
+3VLANVCC: length 45.8
  TOP w0.203: U6.23 286.89,46.87 286.49,46.47 ; U6.11 290.4,50.66 290.38,50.66 290.15,50.89 290.15,51.22 290.2,51.27
  TOP w0.508: v2(290.89,51.47) 291.45,52.03 C208.2 291.28,52.43 C209.2 290.2,52.33 290.2,51.27 ; 291.75,45.66 292.84,44.57 C237.1 292.84,43.13 C249.1 292.74,42.3 v2(292.79,42.25)
  IN2 w0.508: v2(272.37,45.96) 273.29,45.96 274.09,45.16 274.09,42.87 274.68,42.28 278.37,42.28 279.34,41.3 280.32,41.3 280.88,41.87 283.04,41.87 283.19,42.02 284.72,42.02
  IN3 w0.508: v2(290.89,51.47) 290.89,49.57 291.47,48.98 291.47,46.52 293.07,44.92 293.07,42.53 v2(292.79,42.25)
  BOTTOM w0.254: PC167.1 283.86,42.56 283.09,42.56 281.92,41.39 281.92,41.01 281.41,40.5 R445.2
  BOTTOM w0.508: R431.1 288.64,50.76 290.18,50.76 v2(290.89,51.47) ; v2(272.37,45.96) 272.21,46.12 R439.1 271.64,46.24 Q41.2
  vias: v1(285.43,41.74) v2(284.16,43.7) v2(284.84,43.67) v2(285.48,43.67) v2(286.11,43.67)
+5V_ALW: length 172.5
  TOP w0.203: PC63.1 168.86,27.91 PU5.15
  TOP w0.254: v2(182.63,117.33) 182.63,119.29 183.04,119.7 184.95,119.7 185.58,119.06 192.44,119.06 195.44,122.06 204.02,122.06 205.18,120.9 206.75,120.9 207.3,121.45 PR1.1 ; v2(134.89,29.74) 134.87,29.73 134.51,29.73 134.12,29.34 PU4.24
  TOP w0.305: PC43.1 280.3,38.47 280.82,38.99 PU2.4
  TOP w0.381: PC63.1 168.8,28.07 v2(169.27,28.54)
  TOP w0.508: v2(111.52,50.93) 111.19,50.6 109.89,50.6 109.2,51.29 R151.1 ; PR88.1 167.21,30.01 165.39,30.01 164.73,29.35 v2(164.73,28.6) ; v2(279.65,37.82) PC43.1 ; R155.1 106.61,48.5 v2(106.15,48.96) 105.27,48.96 R482.2
  IN1 w0.457: v2(111.52,50.93) 110.36,49.77 108.57,49.77 108.09,49.29 106.49,49.29 v2(106.15,48.96)
  IN1 w2.032: 104.66,82.66 104.78,82.79 104.78,84.85 106.71,86.78 106.71,96.96 113.04,103.29 116.92,103.29 117.6,103.97 120.47,106.84 127.95,106.84
  IN2 w0.254: v2(182.63,117.33) 179.21,120.76 173.46,120.76 v3(172.47,121.75)
  IN2 w2.032: 105.62,76.97 105.62,73.91 104.66,72.94 104.66,55.49 ; 106.38,25.72 104.48,27.62 104.48,41.85
  IN3 w0.508: v2(164.17,23.76) 163.33,24.6 163.33,28.15 163.77,28.6 v2(164.73,28.6) 165.17,28.15 166.76,28.15 167.14,28.54 v2(169.27,28.54)
  BOTTOM w0.381: v2(134.89,29.74) 134.89,29.91 135.28,30.31 136.27,30.31 137.42,29.17 138.87,29.17 140.09,30.39 142.38,30.39 143.52,29.25 144.64,29.25 146.48,27.4
  BOTTOM w0.508: R419.1 25.96,52.07 v2(26.17,52.28) ; ESD2.5 17.89,65.52 v2(18.22,65.19) ; v2(27.41,52.23) 27.25,52.07 R420.1 ; ESD1.5 310.62,72.6 v2(310.19,73.04) ; ESD3.5 v2(17.89,52.82)
  vias: v1(147.38,26.3) v1(169.55,119.09) v1(233.46,21.58) v2(21.9,63.18) v2(21.9,61.73) v2(21.98,63.94) v2(21.95,62.42) v2(27.01,58.71) v2(27.57,58.3) v2(28.05,59.45) v2(28,58.79) v2(104.33,78.88) v2(104.4,80.94) v2(104.38,80.25) v2(104.38,79.54) v2(148.8,22.39) v2(148.98,21.78) v2(149.44,22.39) v2(149.61,21.75) v2(150.07,22.39) v2(150.25,21.75) v2(150.71,23.79) v2(150.71,23.15) v2(150.71,22.39) v2(150.88,21.75) v2(151.32,22.52) v2(151.37,23.79) v2(151.37,23.15) v2(152.03,23.79) v2(152.03,23.15) v2(151.95,22.52) v2(232.39,22.24) v2(232.88,22.92) v2(233.05,22.26) v2(233.61,23.05) v2(233.73,22.44) v2(234.25,23.19) v2(234.38,22.54) v2(234.87,23.18) v2(235,22.55) v2(235.49,23.19) v2(303.51,65.14) v2(303.51,64.38) v2(304.02,64.76) v2(304.02,63.99) v3(108.16,23.58) v3(108.16,22.85) v3(108.92,23.63) v3(108.9,22.87) v3(144.61,23.25) v3(145.4,23.25) v3(146.16,23.2) v3(171.74,122.54) v3(171.74,121.75) v3(172.47,122.54) v3(178.52,19.47) v3(178.57,18.63) v3(178.6,17.79) v3(179.23,19.14) v3(179.36,18.22) v3(180.02,18.76)
+5V_AUDIO: length 7.5
  BOTTOM w0.508: 301.02,42.73 300.97,42.79
  BOTTOM w1.016: 301.02,42.73 306.26,42.73 307.84,41.15
  vias: v1(297.65,42.12) v2(299.32,43.75) v2(300.52,43.67)
+5V_AVDD: length 26.5
  TOP w0.102: v2(310.6,40.63) 310.6,40.98 v1(311.11,41.49)
  TOP w0.305: v2(310.83,32.75) 310.8,32.78 U10.27 ; v2(309.99,39.18) 309.05,39.18 308.56,38.68 U10.38
  IN1 w0.508: v2(310.6,40.63) 310.85,40.63 313.32,38.16 v2(313.32,37.81) 313.01,37.5 313.01,33.13 v2(310.68,30.8)
  BOTTOM w0.508: C493.1 311.05,39.18 v2(309.99,39.18) ; C493.1 C492.1 312.4,38.84 C500.2 v2(313.32,37.81) ; C493.1 C501.1 ; v2(310.68,30.8) 310.68,30.83 C506.1 311.55,31.71 311.55,32.66 C510.1 310.84,32.77 v2(310.83,32.75) ; v2(310.6,40.63) L24.1
+5V_FAN: length 17.4
  TOP w0.102: v2(107.32,54.34) v1(107.32,53.58)
  IN2 w0.508: v2(107.32,54.34) 106.23,53.25 v3(106.08,53.25)
  BOTTOM w0.508: v2(107.32,54.34) 106.43,55.23 R425.2
  BOTTOM w0.762: R438.2 98.13,47.87 99.3,47.87 100.53,49.1 105.05,49.1 105.62,49.67 105.62,52.49 105.47,52.64
+5V_FAN2:
  vias: v1(247.12,53.22) v2(245.27,53.63) v2(245.6,54.32)
+5V_HDMIF1: length 12.6
  BOTTOM w0.508: HDMIF1.2 313.93,89.19 314.37,89.64 315.57,89.64 316.09,90.16 316.09,94.22 314.56,95.74 D9.2 D10.2
  vias: v1(315.58,88.12)
+5V_HDMIF1_D: length 3.1
  BOTTOM w0.102: RP18.1 v1(311.66,91.29)
  BOTTOM w0.305: D10.1 312.02,92.75 312.59,92.19 RP18.1
+5V_HDMIF1_D35: length 3.1
  BOTTOM w0.102: RP18.3 v1(314.15,91.29)
  BOTTOM w0.305: D9.1 313.93,93.08 313.24,92.39 RP18.3
+5V_RUN: length 490.7
  TOP w0.102: PU11.1 245.46,43.73 245.83,43.37 245.83,41.96 245.7,41.84 PU11.3 244.13,41.84 PC249.1 243.19,41.08 v1(243.49,40.78) 244.81,40.78 v2(244.84,40.8)
  TOP w0.254: v3(230.67,52.8) 230.76,52.89 PU1.21
  TOP w0.381: PR34.2 v2(233.66,58.11)
  TOP w0.508: PC31.2 229.9,52.8 v3(230.67,52.8) ; v2(142.97,112.24) 143.54,112.81 143.54,114.72 143.9,115.07 v2(143.9,118.32) ; v2(284.21,30.75) R253.1
  TOP w0.61: v2(111.79,90.71) 111.39,91.12 111.01,91.12 109.71,92.42 109.71,98.41 109.1,99.02 109.1,101.31 108.44,101.97 108.44,102.65 106.41,104.68 v2(106.26,104.68)
  TOP w1.016: v3(95.46,35.34) 95.46,35.09 96.35,34.2 107.25,34.2 107.6,34.56
  TOP w1.524: 117.29,35.19 118.73,36.64 137.35,36.64 138.06,37.35 138.06,46.57 140.22,48.73 166.71,48.73 168,50.02 178.54,50.02 183.02,54.49 191.04,54.49
  IN2 w0.508: v2(233.66,58.11) 237.09,58.11 238.41,56.78 240.73,56.78 242.38,55.14 242.38,54.27 v2(242.25,54.14) ; v2(92.08,47.71) 92.08,39.15 95.46,35.77 v3(95.46,35.34)
  IN2 w0.61: v2(114.84,34.99) 114.84,37.43 112.17,40.09 112.17,41.79 113.27,42.89 113.27,63.02 109.81,66.48 109.81,73.21 111.06,74.46 111.06,89.98 v2(111.79,90.71)
  IN2 w1.016: 311.46,89.01 313.01,87.46 313.01,87.06 315.1,84.97 315.1,80.45 314.16,79.51 314.16,78.62 314,78.47 314,76.41 314.99,75.42 314.99,74.61 314.71,74.33 314.71,66.69 312.53,64.5 311.68,64.5 310.76,63.59 305.8,63.59 303.74,61.53 303.34,61.53 300.97,59.17 300.97,51.42 299.96,50.41 299.07,50.41 296.5,47.84 296.5,45.1 ; 290.64,32.65 291.98,32.65 293,33.67 293,35.48 295.87,38.35 295.87,41.13 296.68,41.95 296.68,43.24
  IN3 w0.508: v2(143.9,118.32) 143.9,124.29 143.29,124.9 138.34,124.9 138.08,124.65 125.86,124.65 v2(125.2,123.99) ; v2(142.97,112.24) 142.12,111.39 139.53,111.39 137.3,109.16 127.97,109.16 125.03,106.21 119.97,106.21 117.76,104 110.55,104 109.81,104.74 106.31,104.74 v2(106.26,104.68) ; v2(18.02,98.49) 16.89,97.36 16.89,87.32 19.32,84.88 24.97,79.23 24.97,67.99 42.07,50.89 47.73,50.89 50.07,48.55 91.25,48.55 v2(92.08,47.71)
  BOTTOM w0.191: PQ26.2 v2(143.9,118.32) ; PQ24.2 125,123.79
  BOTTOM w0.203: PC115.1 143.9,116.65 v2(143.9,118.32)
  BOTTOM w0.508: v2(92.08,47.71) 92.24,47.87 96.15,47.87 R438.1 ; 125,123.79 v2(125.2,123.99) 125.87,124.66 PC85.1 125.87,125.69 125.61,125.94 125.61,126.18 125.39,126.4 118.12,126.4 116.59,124.88 PR132.2
  vias: v2(191.91,55.26) v2(192.36,54.8) v2(192.79,54.32) v2(236.99,25.08) v2(237.68,25.82) v2(237.68,25.18) v2(237.68,24.55) v2(237.68,23.89) v2(238.32,25.28) v2(238.3,24.64) v2(238.36,25.92) v2(245.22,51.34) v2(246.57,51.22) v2(253.01,44.83) v2(253.64,44.83) v2(254.28,44.83) v2(254.91,44.83) v2(255.55,44.83) v2(256.18,44.83) v2(290.03,30.67) v2(290.03,29.98) v2(290.08,31.38) v2(296.65,44.23) v2(297.34,44.23) v2(309.99,89.27) v2(310.12,88.63) v2(310.62,89.27) v2(311.26,89.27)
+5V_RUN_F: length 2.8
  TOP w0.508: v1(23.07,99.73) 22.3,98.96 HDMIF2.1 23.43,98.44 v2(23.48,98.49)
+5VPCU: length 190.8
  TOP w0.254: PR57.1 243.26,46.41 v2(243.77,46.93) ; 131.42,32.63 131.42,32.08 131.21,31.86 PU4.4
  TOP w0.279: PC72.1 133.84,24.38 133.35,24.38 132.55,25.18 132.43,25.18 132.21,25.41 PU4.17
  TOP w0.381: 131.42,32.63 131.42,33.41 132.62,34.61 137.17,34.61 138.4,33.37 146.13,33.37 146.55,32.95 146.55,30.31 146.43,30.19 146.43,29.43 145.86,28.86 144.14,28.86 v2(143.75,28.47)
  TOP w0.508: v2(183.42,25.13) 183.83,25.13 184.18,25.49 v1(184.18,26.43) 184.18,29.68 181.34,32.52 179.21,32.52 178.48,33.26 176.54,33.26 175.27,34.53 167.42,34.53 166.96,34.07 165.29,34.07 164.63,33.41 158.25,33.41 154.57,29.73 154.57,28.08 154.09,27.6 153.48,26.99 147.22,26.99 146.62,27.59 146.15,28.05 144.16,28.05 v2(143.75,28.47) ; v2(134,25.23) 134,24.53 PC72.1
  IN3 w0.508: v2(240.9,27.39) 240.9,23.56 238.87,21.53 238.87,18.1 238.26,17.49 189.21,17.49 187.33,19.37 187.33,21.78 185.95,23.16 184.43,23.16 183.47,24.12 183.47,24.8 183.42,24.85 v2(183.42,25.13)
  BOTTOM w0.508: v2(134,25.23) 134,28.01 134.69,28.7 136.33,28.7 137.04,28 140,28 140.47,28.47 v2(143.75,28.47) ; v2(240.9,27.39) 241.66,28.15 241.66,32.19 241.99,32.52 242.48,32.52 244.53,34.58 244.53,37.91 246.65,40.03 246.65,43.87 243.77,46.75 v2(243.77,46.93)
+12V_ALW: length 529.8
  TOP w0.203: 202.93,24.07 PU6.13
  TOP w0.254: 202.93,24.07 203.31,24.45 PC70.1 203.16,25.25 202.62,24.71 v2(202.62,24.65) ; R246.1 281.82,33.49 280.22,35.09 279.54,35.09 279.05,34.61 279.05,34.12 278.6,33.67 v4(277.12,33.67)
  TOP w0.508: R244.2 v2(88.27,30.97) ; PD8.1 63.04,26.29 v2(62.47,26.86) ; v2(108.64,37.91) 107.45,36.71 94.62,36.71 92.95,35.04 v2(92.95,33.9) ; Q4.1 157.01,113.21 R11.2 158.65,113.21 v2(158.76,113.32)
  IN1 w0.508: v2(218.04,121.25) 218.42,121.63 221.83,121.63 222.18,121.27 v2(222.18,119.95) ; v2(62.47,26.86) 63.03,26.3 74.66,26.3 76.46,24.5 88.96,24.5 89.52,23.94 100.36,23.94 101.56,25.13 108.14,25.13 108.54,25.54 v2(108.54,25.89) ; v2(158.76,113.32) 157.35,113.32 156.82,113.85 151.95,113.85 149.54,111.44 143.59,111.44 142.5,110.35 140.06,110.35 138.18,108.46 133.44,108.46 129.7,104.72 120.28,104.72 117.38,101.81 113.83,101.81 108.9,96.89 v3(108.9,96.35)
  IN2 w0.254: v2(108.54,25.89) 109.33,25.89 110.52,27.09 116.14,27.09 117.97,28.92 118.96,28.92 121.3,31.26 145.44,31.26 146.29,30.42 146.29,28.18 147.71,26.76 154.29,26.76 155.08,27.55 155.08,29.58 157.39,31.89 161.2,31.89 162.67,33.36 182.66,33.36 182.99,33.69 184.95,33.69 185.73,34.48 192.47,34.48 192.56,34.39 194.48,34.39 195.49,35.39 198.53,35.39 199.02,34.91 v2(199.02,34.42) ; v2(224.11,20.97) 224.11,20.98 224.86,21.73 226.73,21.73 230.7,25.7 230.7,28.1 231.53,28.93 231.53,29.6 238.74,36.82 240.27,36.82 241.89,38.44 243.47,38.44 244.28,39.24 244.28,42.23 248.38,46.33 248.38,48.67 248.56,48.84 255.37,48.84 255.98,48.23 257.84,48.23 259.96,46.11 262.03,46.11 263.32,44.83 263.32,43.64 266.02,40.94 271.45,40.94 272.68,39.71 273.9,39.71 274.71,38.9 274.71,37.6 277.12,35.19 v4(277.12,33.67)
  IN2 w0.508: v3(181.32,112.41) 181.32,109.35 184.84,105.83 190.86,105.83 192.26,107.22 195.33,107.22 199.2,111.09 205.77,111.09 206.87,112.18 206.87,113.02 210.41,116.56 210.41,121.39 210.04,121.75 210.04,123.68 210.8,124.45 214.59,124.45 217.79,121.25 v2(218.04,121.25) ; v3(108.9,96.35) 110.24,95.01 110.24,76.16 108.8,74.71 108.8,55.97 109.27,55.5 109.27,39.19 108.64,38.57 v2(108.64,37.91) 108.64,36.31 107.12,34.79 107.12,27.31 v2(108.54,25.89)
  IN3 w0.508: v2(158.76,113.32) 159.8,114.36 163.71,114.36 164.43,115.09 166.75,115.09 166.99,114.84 170.44,114.84 171.59,115.99 172.64,115.99 172.95,116.3 173.42,116.78 176.29,116.78 176.96,116.78 v3(181.32,112.41)
  BOTTOM w0.254: v2(199.02,34.42) 199.02,27.11 201.48,24.65 v2(202.62,24.65) 202.62,24.4 202.37,24.14 200.67,24.14 200.24,23.71 200.24,23.07 200.87,22.44 203.41,22.44 206.15,19.7 207.86,19.7 209.13,20.97 211.56,20.97 211.92,21.32 223.71,21.32 224.06,20.97 v2(224.11,20.97)
  BOTTOM w0.457: v2(222.18,119.95) 222.11,119.87 PR146.2 PR151.1
  BOTTOM w0.508: v2(92.95,33.9) 92.95,33.51 90.41,30.97 v2(88.27,30.97) ; v2(218.04,121.25) 218.27,121.25 218.56,120.96 PR141.1
+V1.05A_AOSCSUS: length 29
  TOP w0.254: v1(170.62,92.9) 170.8,93.08 L8.2
  TOP w0.508: v2(163.25,91.28) 164.47,90.05 165.46,90.05 165.95,90.54 168.25,90.54 C120.1 C121.1 C122.1 171.07,90.4 C117.2 171.84,92.16 172.19,92.51 L8.2
  IN2 w0.203: 159.34,89.8 159.02,90.13 158.33,90.13 157.89,89.68 156.16,89.68 155.73,90.11 v2(155.73,90.16) 155.48,89.91 155.48,89.29 156.04,88.73 158.94,88.73 159.29,89.09
  IN2 w0.508: v2(163.25,91.28) 163.64,90.89 163.64,89.8 163.28,89.44 159.7,89.44
  BOTTOM w0.254: U14.AB8 155.56,89.98 v2(155.73,90.16)
+V1.05DX_MODPHY: length 3.2
  TOP w0.508: C18.2 154.91,108.45 154.69,108.67 C11.1 ; v2(154.03,94.3) 153.86,94.47 C84.2 C95.2
  vias: v1(155.91,100.62) v1(167.52,121.22) v2(154.14,95.19) v3(156.19,107.12) v3(156.9,107.4) v3(159.49,118.76) v3(160.23,118.76) v3(160.97,118.76) v3(161.7,118.76) v3(163.94,118.86) v3(164.57,119.34) v3(164.7,118.38) v3(165.27,119.14)
+V1.05S_APLLOPI: length 2.1
  TOP w0.508: v1(144.9,86.4) 144.9,87.36 144.87,87.39
  BOTTOM w0.254: v2(148.09,89.85) 148.46,90.22 U14.AA21 ; U14.W21 148.46,91.03 v2(148.08,90.66)
+V1.05S_ASATA3PLL: length 7.1
  BOTTOM w0.254: U14.B11 153.89,101.1 154.24,101.45 154.24,101.84 154.29,101.89 154.29,102.73 154.62,103.06 156.25,103.06 158.11,104.91 R294.2
  vias: v1(157.23,110.15)
+V1.05S_AUSB3PLL: length 15.7
  TOP w0.508: R19.1 R20.1 146.47,109.65 146.91,109.65 v2(147.43,110.17) 147.43,110.4 v1(146.97,110.86)
  IN3 w0.508: v2(147.43,110.17) 147.51,110.17 148.9,108.77 149.84,108.77 151.75,106.87 v2(151.75,106.72)
  BOTTOM w0.254: U14.B18 149.15,101.21 149.15,101.9 150.02,102.76 150.02,103.54 150.88,104.41 151.09,104.41 C424.1
+V1.05S_AXCK_DCB: length 23.8
  TOP w0.229: 150.05,99.55 149.92,99.43 149.92,98.66 149.88,98.62 C55.1
  TOP w0.254: C55.1 150.37,97.47 150.88,97.98 150.88,99.25 150.73,99.4 150.73,99.48 150.68,99.53
  TOP w0.508: v2(149.52,96.84) 149.88,97.2 C55.1 ; 150.27,100.44 151.87,100.44 152.89,101.46 152.89,104.46 151.9,105.45 150.53,105.45 149.59,106.39 149.59,107.1 149.96,107.47 C19.1 149.96,108.73 C12.2 149.74,110.57 L2.2 149.58,110.96 148.45,112.1 v1(148.45,112.13)
  BOTTOM w0.254: U14.J18 149.6,96.84 v2(149.52,96.84) 149.44,96.76 U14.K19
+V1.05S_AXCK_LCPLL: length 5.9
  TOP w0.508: R21.2 146.84,108.88 v1(147.47,108.88) 147.58,108.88 v2(148.17,108.29)
  BOTTOM w0.254: U14.A20 148.62,101.85 149.56,102.79 149.56,104.35 C425.1
+V1.05S_VCCST: length 115.3
  TOP w0.457: v2(124.85,112.18) 125.18,112.18 125.46,111.9 R15.1 125.42,111.59 124.22,111.59 R14.1 ; R12.2 122.03,111.42 121.68,111.77 v2(121.27,111.77)
  TOP w0.508: v2(117.2,120.38) 117.2,120.64 PR2.1 ; v1(112.63,102.22) 112.99,101.86 R33.2 112.99,100.93 112.76,100.7 112.76,100.34 113.47,99.63 113.83,99.63 R37.2 113.6,98.51 v2(112.96,98.51)
  IN1 w0.508: v2(105.27,104.74) 105.27,104.51 105.77,104 107.98,104 111.16,107.17 111.16,110.04 113.19,112.08 117.2,112.08 118.29,110.99 120.31,110.99 121.27,111.95 v2(121.27,111.77) ; v2(145.4,94.22) 145.4,93.71 145.02,93.33 142.96,93.33 142.22,92.59 125.1,92.59 124.27,93.43 120.89,93.43 120.43,92.98 117.36,92.98 v2(116.72,93.61)
  IN2 w0.508: v2(112.96,98.51) 112.96,96.86 113.03,96.79 113.03,93.95 114.66,92.32 115.88,92.32 116.72,93.15 v2(116.72,93.61)
  IN3 w0.508: v2(117.2,120.38) 115.22,120.38 113.42,118.58 113.42,115.38 117.03,111.77 v2(121.27,111.77) 121.7,111.34 124.29,111.34 124.85,111.9 v2(124.85,112.18) ; v2(105.27,104.74) 105.27,104.51 105.77,104 107.81,104 112.96,98.84 v2(112.96,98.51)
  BOTTOM w0.254: U14.AE23 147.43,88.22 U14.AE22 U14.AC22
  BOTTOM w0.457: v2(116.72,93.61) 116.82,93.71 R320.1
  BOTTOM w0.508: U14.AE23 146.7,87.81 146.24,88.28 146.24,90.33 145.6,90.97 v2(145.6,91.88) ; v2(112.96,98.51) 112.96,97.07 R311.2 114.01,96.64 R313.1
+V3.3_THERMAL: length 62.5
  TOP w0.305: v2(118.98,61.84) 119.49,61.84 120,62.34 120,62.98 119.74,63.23 Q17.5 ; v2(112.76,65.01) 112.76,64.89 113.66,63.99 RP9.4 113.06,63.68 112.89,63.51 112.89,63.3 113.15,63.03 RP9.2 ; Q17.2 116.06,63.23 115.81,63.49 115.81,64.38 v2(116.06,64.63) ; R115.1 111.22,74.04 110.86,73.68 110.86,72.55 v2(111.06,72.35)
  TOP w0.432: U3.1 115.39,72.44 115.68,72.73 116.35,72.73 C194.1 v2(117.3,72.38)
  TOP w0.508: R139.1 113,65.26 v2(112.76,65.01)
  IN2 w0.508: v2(118.98,61.84) 118.98,63.11 117.46,64.63 v2(116.06,64.63) 113.14,64.63 v2(112.76,65.01) 111.06,66.71 v2(111.06,72.35) 111.06,72.83 112.26,74.04 115.63,74.04 117.29,72.38 v2(117.3,72.38)
  BOTTOM w0.508: R427.1 94.48,59.55 94.48,59.43 96.64,57.26 99.3,57.26 100.26,58.23 103.77,58.23 v1(105.53,59.99) 110.55,65.01 v2(112.76,65.01)
+V3.3_THERMAL2: length 13.5
  TOP w0.102: RP8.4 173.22,66.19 v2(173.52,66.48)
  TOP w0.254: Q15.2 176,65.98 v2(175.8,66.18)
  TOP w0.508: C199.1 185.4,64.07 184.54,63.21
  TOP w0.762: 183.14,66.51 183.12,66.48 181.9,66.48 180.86,67.52 177,67.52
  vias: v1(176.31,67.83) v2(175.27,67.22) v2(175.9,67.22)
+V3.3DX_CR: length 3.6
  TOP w0.381: R199.1 52.68,36.09 52.88,35.89 v2(53.53,35.89)
  TOP w0.457: v2(52.68,41.26) R177.2
  TOP w0.508: v2(56.49,29.95) 55.99,29.95 R243.2 ; R188.1 52.68,38.51 v2(53.07,38.9)
  vias: v1(59.57,27.75) v2(59.11,28.54) v2(59.83,28.54) v2(61.73,39.36) v2(62.36,39.33)
+V3.3S_1.8S_LPSS_SDIO: length 25.9
  TOP w0.508: v2(155.73,93.02) 155.51,93.02 C102.1
  IN2 w0.203: 159.7,93.05 159.65,93 159.65,92.37 159.44,92.16 158.3,92.16 157.93,92.53 157.89,92.53 157.88,92.54 157.49,92.54 157.48,92.53 157.23,92.53 157.23,92.54 156.84,92.54 156.83,92.53 156.58,92.53 156.58,92.54 156.19,92.54 156.18,92.53 155.73,92.98 v2(155.73,93.02) 155.73,93.15 156.08,93.5 157.55,93.5 159.46,93.5
  IN2 w0.508: v2(162.92,95.36) 161.78,94.22 160.82,94.22 160.13,93.53
  IN3 w0.508: v2(168.66,101.65) 168.66,101.64 167.27,100.24 166.38,100.24 162.92,96.79 v2(162.92,95.36)
  BOTTOM w0.254: U14.T9 v2(155.73,93.02) 155.56,92.84 U14.U8
  BOTTOM w0.508: R315.2 v2(162.92,95.36) ; R299.2 168.92,102.59 168.92,101.89 168.66,101.64 v2(168.66,101.65)
+VCCIN: length 12.8
  TOP w0.381: v2(116.59,99.43) 116.59,99.35 118.14,97.8 119.19,97.8 119.72,98.33 v2(119.72,99.17)
  IN1 w0.381: v2(119.72,99.17) 121.85,99.17 122.82,100.14 125.08,100.14 v2(126.04,99.17)
  BOTTOM w0.381: R304.2 116.65,99.48 v2(116.59,99.43)
  vias: v1(140.83,113.37) v2(125.33,96.76) v2(125.31,95.52) v2(125.69,93.99) v2(125.69,93.23) v2(125.76,91.98) v2(125.76,90.71) v2(125.76,89.34) v2(125.76,87.9) v2(125.76,87.06) v2(126.09,97.7) v2(126.75,97.68) v2(127.88,97.68) v2(128.58,99.17) v2(129.26,97.68) v2(130.38,97.68) v2(131.07,99.17) v2(131.76,97.68) v2(132.89,97.68) v2(133.69,99.17) v2(134.27,97.68) v2(135.4,97.68) v2(135.96,99.15) v2(136.78,97.68) v2(137.91,97.68) v2(138.73,99.15) v2(139.29,97.68) v2(140.41,97.68) v2(141.18,99.15) v2(141.79,97.68) v2(142.32,97.22) v2(142.92,97.68) v2(143.62,99.17) v2(143.59,97.98) v2(143.57,97.32) v2(144.3,97.68) v2(144.74,94.09) v2(144.84,91.07) v2(144.89,91.86) v2(146.06,99.17) v2(146.26,98) v2(146.26,97.37) v3(130.77,117.66) v3(131.14,117.04) v3(131.4,118.5) v3(131.53,117.69) v3(131.82,115.96) v3(131.86,116.78) v3(132.15,115.31) v3(132.19,118.53) v3(132.27,117.69) v3(132.55,115.96) v3(132.62,116.78) v3(132.95,118.53) v3(133,117.69) v3(132.95,115.3) v3(133.41,116.78) v3(133.41,115.94) v3(133.74,118.53) v3(133.76,117.69) v3(133.87,115.3) v3(134.17,116.78) v3(134.35,115.96) v3(134.5,118.53) v3(134.5,117.69) v3(134.76,115.3) v3(134.96,116.78) v3(135.24,117.69) v3(135.29,118.53) v3(135.31,115.94) v3(135.75,116.78) v3(135.72,115.28) v3(136,117.69) v3(136.05,118.55) v3(136.23,115.94) v3(136.51,116.78) v3(136.74,117.69) v3(136.71,115.28) v3(136.84,118.55) v3(137.14,115.96) v3(137.3,116.78) v3(137.5,117.69) v3(137.63,118.55) v3(137.59,115.33) v3(137.98,115.94) v3(138.06,116.78) v3(138.31,117.69) v3(138.36,118.55)
+VCCIO_OUT: length 48
  TOP w0.508: v2(117.2,119.67) 116.9,119.67 116.58,119.99 PR3.1
  IN2 w0.508: v2(126.93,112.94) 126.93,107.58 125.54,106.18 125.54,104.68 124.11,103.26 124.11,102.81 124.09,102.78 v2(124.09,102.35) 124.09,101.71 121.47,99.1 121.47,98.28 121.88,97.88 121.88,96.38 121.04,95.54 117.61,95.54 v2(116.72,94.65)
  IN3 w0.508: v2(117.2,119.67) 117.66,119.67 118.32,119.01 118.32,116.43 119.21,115.54 126.67,115.54 127.67,114.54 127.67,113.3 127.31,112.94 v2(126.93,112.94) ; v2(116.72,94.65) 116.72,94.55 116.52,94.35 116.31,94.35 116.29,94.33 115.72,94.33 115.67,94.28 v2(115.04,94.28)
  BOTTOM w0.254: U14.A59 124.11,101.87 124.11,102.32 v2(124.09,102.35)
  BOTTOM w0.457: R316.1 116.92,94.86 v2(116.72,94.65) ; R317.2 114.66,94.67 v2(115.04,94.28) 114.66,93.89 R321.1
  BOTTOM w0.508: v1(113.42,94.7) 113.57,94.86 R317.2
+VCCIOA_OUT: length 10.7
  TOP w0.254: R22.2 147.81,107.67 147.81,105.55 v1(147.15,104.89) 146.49,104.23 146.49,102.07 146.92,101.64 147.22,101.64 147.95,100.9 147.95,99.54 v2(148.45,99.05)
  BOTTOM w0.254: v2(148.45,99.05) 148.89,99.05 U14.E20
+VCCRTCEXT: length 2.4
  TOP w0.305: v2(156.38,88.26) 156.38,88.39 155.52,89.26 C131.2
  BOTTOM w0.305: v2(156.38,88.26) 156.38,87.96 U14.AE7
+VIN: length 249.8
  TOP w0.102: PR188.1 253.26,47.35 253.02,47.59 253.02,49.79 252.55,50.25 249.66,50.25 249.26,49.85 246.62,49.85 246.11,49.34 244.03,49.34 243.54,48.86 v2(243.54,47.87)
  TOP w0.254: R479.1 282.43,25.41 v2(282.46,25.39)
  TOP w0.508: v2(130.23,20.72) PR113.2 130.64,21.53 127.97,21.53 127.6,21.91 127.6,22.45 PR106.1 ; PR80.1 169.58,32.64 167.9,32.64 ; PR117.2 v2(197.47,19.29) ; v2(92.54,25.36) 92.76,25.14 PR100.1 ; 167.9,32.64 EC7.2 ; 167.9,32.64 167.9,32.83 167.37,33.36 165.44,33.36 164.88,32.8 158.5,32.8 155.18,29.48 155.18,26.61 v1(155.35,26.43) 155.35,25.47 v2(155.36,25.47)
  IN1 w0.102: v2(243.54,47.87) 242.93,47.26 237.73,47.26 236.96,46.49 231.99,46.49 231.22,47.26 v3(218.63,47.26)
  IN2 w1.27: 213.44,39.99 213.22,40.22 213.22,45.15 214.31,46.24 ; 219.74,40.64 219.74,45.2 219.11,45.83 ; 215.78,45.5 215.68,45.4 215.68,43.52 215.27,43.12 215.27,40.4 215.6,40.07 ; 218.04,40.18 217.38,40.84 217.38,45.83
  IN2 w1.524: 196.43,18.32 196.61,18.14 234.9,18.14 240.7,23.94 243.31,23.94 245.42,26.05 258.43,26.05 259.52,24.95
  IN3 w0.508: v2(109.2,108.24) 109.2,107.33 111.77,104.76 116.47,104.76 121.77,110.06 v2(123.01,110.06)
  IN3 w1.016: 101.1,78.95 101.1,80.04 arc(103.26,85.56) 104.63,91.32 104.71,91.53 104.81,92.01 104.81,93.97 105.39,94.55 105.39,100.21 105.9,100.72
  BOTTOM w0.305: PR168.1 104.94,110.8 104.94,108.55 105.42,108.06 107.91,108.06 108.09,108.24 v2(109.2,108.24)
  BOTTOM w0.508: v2(123.01,110.06) 121.98,111.1 121.98,112.61 119.77,114.82 119.21,114.82 118.22,115.81 118.22,119.42 118.12,119.52
  BOTTOM w0.762: Q28.1 282.05,27.55 282.46,27.14 C521.1 v2(282.46,25.39) 282.46,25.16 281.54,24.24 273.39,24.24 273.16,24.47 265.82,24.47 264.14,26.15 260.79,26.15 259.85,25.21 259.85,24.93
  vias: v1(36.36,44.61) v1(40.24,35.77) v1(78.24,49.49) v1(123.2,19.34) v1(133.33,17.44) v1(147.94,125.46) v1(201.02,124.37) v1(213.85,46.93) v1(217.25,51.12) v2(37.83,44.48) v2(37.85,43.79) v2(38.45,44.47) v2(38.48,43.78) v2(39.08,44.06) v2(39.1,43.36) v2(39.74,44.06) v2(39.77,43.37) v2(40.75,26.4) v2(40.75,25.77) v2(40.75,25.13) v2(41.38,26.4) v2(41.38,25.77) v2(41.38,25.13) v2(42.02,26.4) v2(42.02,25.77) v2(42.02,25.13) v2(201.15,126.1) v2(201.15,125.34) v2(204.96,126.22) v2(204.96,125.46) v2(205.98,125.59) v2(206.08,126.25) v2(259.75,24.09) v2(260.05,23.53) v2(260.38,24.09) v3(56.47,18.07) v3(57.36,18.05) v3(58.23,18.05) v3(59.06,18.02) v3(59.9,17.99) v3(65.13,44.69) v3(65.13,43.93) v3(66.02,44.69) v3(66.02,43.93) v3(66.91,44.69) v3(78.19,50.96) v3(78.95,51.22) v3(79.69,51.55) v3(83.85,17.56) v3(84.74,17.54) v3(85.61,17.54) v3(86.44,17.51) v3(87.28,17.49) v3(99.78,77.23) v3(99.78,76.41) v3(99.78,75.58) v3(99.78,74.81) v3(100.67,77.25) v3(100.67,76.44) v3(100.67,75.6) v3(100.67,74.84) v3(105.19,102.6) v3(105.27,101.64) v3(105.29,100.57) v3(105.93,102.3) v3(106.05,101.46) v3(106.46,102.91) v3(106.84,102.25) v3(119.34,120.46) v3(120.07,120.48) v3(120.15,121.22) v3(120.63,119.95) v3(120.61,119.21) v3(127.29,17.05) v3(127.36,18.76) v3(127.36,17.84) v3(128.05,17.39) v3(128.08,18.3) v3(128.81,18.73) v3(128.76,17.89) v3(128.81,17.05) v3(139.94,125.59) v3(139.96,126.35) v3(140.06,124.22) v3(140.09,123.46) v3(140.7,126.35) v3(140.7,125.59) v3(140.8,124.22) v3(140.83,123.43) v3(149.61,119.95) v3(149.74,17.94) v3(149.67,17.08) v3(149.77,18.71) v3(150.53,120.02) v3(150.55,17.11) v3(150.71,17.99) v3(150.76,18.83) v3(151.62,122.62) v3(151.65,121.8) v3(152.38,122.67) v3(152.38,121.91) v3(153.14,122.67) v3(213.72,51.4) v3(214.13,50.79) v3(214.54,51.4) v3(214.84,46.85) v3(214.94,50.79) v3(215.32,51.42) v3(215.63,46.85) v3(215.71,50.79) v3(216.11,51.42) v3(216.42,46.85) v3(216.52,50.79) v3(217.15,46.85) v3(217.91,46.82) v3(218.65,46.49)
AGND: length 24.3
  TOP w0.305: v2(310.85,32.07) 310.8,32.07 310.59,32.28 U10.26 ; U10.33 310.95,35.78 v2(311.16,35.57)
  TOP w0.483: R270.1 309.35,26.28 309.66,25.97 v2(309.74,25.97)
  TOP w0.508: C289.1 314.13,37.55 v2(314.13,37.81) ; v2(298.61,25.79) 298.51,25.89 R273.2 ; v2(309.04,25.63) 307.85,25.63 R276.1 ; v2(309.49,39.78) 309.74,40.02 309.74,41 C259.1 ; C337.2 v2(315.19,31.24) ; C355.2 308.57,27.19 v2(308.67,27.29) 309.1,27.72 R266.2 ; C353.1 315.38,27.23 v2(315.46,27.23) ; C338.1 312.76,29.02 C352.1 311.66,28.92 v2(311.24,29.34) ; C284.2 v2(315.7,38.57) ; C278.1 v2(322.68,37.95) ; v2(313.18,31.32) 313.09,31.23 C332.2
  BOTTOM w0.508: C520.1 307.46,29.43 307.08,29.81 307.08,29.95 v2(307.03,30) ; C488.1 311.55,41.25 v2(311.74,41.06) ; C492.2 312.15,40.4 v2(312.28,40.52) ; Q48.1 313.94,28.45 v2(314.35,28.04) ; C493.2 v2(310.41,39.87) ; C510.2 313.13,32.17 v2(312.79,31.84) 312.48,31.52 C506.2 ; C501.2 311.13,35.6 v2(311.16,35.57)
  vias: v1(314.77,38.77) v2(313.8,39.76) v2(317.59,28.46) v2(317.85,32.2) v2(318.54,36.2) v2(325.47,36.2)
AV12: length 14
  TOP w0.102: v1(64.97,35.69) 64.77,35.89 62.89,35.89 62.68,35.68 62.68,35.43 62.55,35.29 C315.1
  TOP w0.203: C262.1 61.95,40.06 61.8,39.91 61.6,39.91 61.22,39.53 61.22,39.48 60.42,38.69 U9.14 ; 60.97,36.69 60.57,37.09 U9.10
  TOP w0.508: 60.97,36.69 61.06,36.6 61.91,36.6 C299.1 62.07,35.38 C315.1 61.88,35.29 61.35,35.82 v2(61.17,35.82) ; v2(61.35,42.96) 61.47,42.84 C254.1 61.47,42.02 61.95,41.55 C262.1
DV33_18: length 3.3
  TOP w0.102: v1(57.68,42.57) 57.97,42.28 C253.2
  TOP w0.203: 58.77,41.37 58.77,41.36 U9.18
  TOP w0.508: 58.77,41.37 C253.2
GND: length 1124.6
  TOP w0.102: VRAM2.B1 221.11,74.43 221.47,74.79 v2(221.5,74.79) ; 205.34,85.71 v2(205.29,85.71) ; 197.54,97.56 197.54,97.57
  TOP w0.178: v2(311.36,78.8) 311.12,79.05 U2.8 ; U2.49 308.92,82.86 U2.35
  TOP w0.203: U7.40 v2(266.32,44.5) ; U7.8 267.02,40.9 267.22,40.69 267.22,40.45 267.27,40.4 v2(267.22,40.4) 267.44,40.17 U7.12 ; v2(270.42,43.39) 270.72,43.7 U7.30 ; U7.26 270.42,42.1 v2(270.42,42.1) ; U7.22 270.46,40.5 v2(270.42,40.45) 270.42,40.22 270.64,39.99 U7.20
  TOP w0.254: VRAM1.M9 221.69,101.07 v2(221.79,101.17) ; v2(214.16,97.24) 214.72,97.8 VRAM1.T1 ; PQ50.4 62.18,19.15 62.42,18.91 v2(62.42,18.55) ; C226.1 140.19,42.99 139.84,42.63 v2(139.61,42.63) ; VRAM1.G9 221.09,105.07 v2(220.68,104.67) 220.32,105.04 VRAM1.G8 ; R512.2 v2(249.01,33) ; VRAM2.E2 220.71,76.42 v2(220.71,76.39) ; VRAM2.B9 214.32,74.42 214.1,74.2 v2(214.1,74.15) 214.64,73.62 VRAM2.A9 ; VRAM2.G8 215.49,78.42 215.12,78.05 ; PC58.1 51.95,26.06 PC57.2 52.36,27.07 52.49,27.2 PR87.2 ; v2(286.75,31.56) 286.9,31.71 286.9,31.94 286.74,32.1 Q24.4 ; v2(221.56,82.79) 221.56,82.77 221.2,82.42 VRAM2.M1 ; Q3.1 v2(165.96,114.46) ; v2(215.9,103.08) 215.51,103.47 VRAM1.J2 ; PQ16.1 49.83,23.29 49.59,23.53 v2(49.46,23.53) ; PQ50.1 60.04,20.45 v2(60.51,20.92) ; PU3.14 47.23,30.74 v2(47.07,30.9) ; v2(219.9,103.9) 220.32,103.49 VRAM1.J8 ; C243.2 v2(112.38,43.67) ; v2(218.98,73.85) 219.08,73.85 219.46,74.23 219.46,74.36 VRAM2.B3 ; U25.24 257.5,28.07 257.62,27.95 v2(258.05,27.95) ; R511.2 259.43,38.69 258.8,39.32 v2(258.8,39.55) ; VRAM2.E1 221.22,76.71 221.22,76.12 VRAM2.D1 ; U10.49 306.56,34.78 U10.42 ; 215.12,78.05 214.75,78.42 VRAM2.G9 214.52,78.22 v2(214.05,78.22) ; 215.12,78.05 214.72,77.64 VRAM2.F9 ; VRAM2.E8 215.51,76.81 v2(215.9,76.43) 215.51,76.05 VRAM2.D8 ; PU1.22 231.23,52.39 v2(231.12,52.28) ; VRAM2.P1 221.24,84.02 221.72,84.49 222,84.49 v2(222.03,84.52) ; v2(34.93,23.02) 35.69,23.02 PR109.1 ; v2(106.1,44.77) 106.1,45.27 106.23,45.4 106.52,45.4 106.65,45.27 Q19.1 ; C393.1 282.84,33.41 283.04,33.62 283.13,33.62 v2(283.26,33.74) 283.26,33.71 283.56,33.4 Q24.1 ; Q46.4 v2(90.8,33.41) ; C221.2 v2(112.33,46.72) ; VRAM2.G1 221.46,78.42 221.62,78.25 v2(221.62,78.12) ; v2(186.04,19.8) 186.29,19.8 186.66,19.43 Q32.1 ; VRAM1.P1 v2(215.11,99.08) ; VRAM2.T1 221.11,85.96 v2(221.34,86.19) ; v2(219.92,80.4) 219.99,80.33 220.3,80.02 VRAM2.J2 ; v2(150.43,42.53) 150.45,42.53 150.99,43.06 C229.2 ; VRAM2.T9 214.72,85.91 214.08,86.54 v2(214.08,86.55) ; Q27.1 93.25,27.82 93.86,27.21 93.86,26.83 94.47,26.22 v2(94.47,26.05) ; Q3.4 167.26,117.14 167.57,116.83 v2(167.8,116.83) ; v2(214.23,105.55) 214.71,105.07 VRAM1.G1 ; PU5.17 170.13,26.91 v2(169.73,26.5) ; v2(214.13,100.9) 214.29,101.06 214.71,101.06 VRAM1.M1 ; C233.2 v2(112.4,44.69) ; v2(261.53,31.66) 261.87,31.32 R506.1 ; Q45.1 v2(91.92,31.36) ; v2(108.49,47) 108.24,46.74 Q19.4 ; VRAM2.J8 215.52,80.02 v2(215.92,80.42) ; 16.69,90.6 17.17,90.12 PQ5.1 20.52,90.12 20.77,89.88 20.77,89.02 20.94,88.84 21.83,88.84 PQ5.4 21.85,88.17 v2(21.83,88.15) ; v2(18.25,81.88) 18.25,82.64 18.46,82.84 PC17.2 19.65,82.84 20.08,83.28 PQ6.4 20.08,84.1 20.37,84.4 21.14,84.4 21.38,84.64 PQ6.1 21.77,85.89 PR25.1 ; PQ16.4 51.13,24.23 51.44,23.91 52.02,23.91 v2(52.04,23.89) PR102.2 ; U25.31 v2(259.09,32.11) ; U25.18 v2(254.5,27.49) ; Q32.4 187.96,21.82 v2(188.15,22.01) ; VRAM1.E2 215.51,106.7 215.91,107.1 v2(215.91,107.05) ; v2(250.35,33.87) 250.61,33.61 U25.3 ; R161.1 v2(112.33,45.71)
  TOP w0.279: Q44.4 104.85,47.63 v2(105.24,48.02) ; U5.3 112.49,57.15 ; Q44.1 v2(103.55,43.62)
  TOP w0.305: PU2.5 282.67,38.99 282.18,39.48 PU2.9 ; v2(111.62,57.77) 111.62,57.59 111.82,57.39 112.25,57.39 112.49,57.15 ; VRAM1.B9 221.11,109.1 v2(221.52,109.51) 221.48,109.51 VRAM1.A9 ; v2(220.71,76.39) 221.08,76.02 VRAM2.D1 ; VRAM1.E1 214.7,106.67 214.28,107.09 v2(214.21,107.09) 214.59,107.47 VRAM1.D1
  TOP w0.356: VRAM1.B3 216.89,109.07 217.05,109.23 v2(217.13,109.23) ; v2(221.72,105.52) 221.38,105.87 VRAM1.F9 ; VRAM1.E8 220.31,106.67 219.89,107.08 v2(219.95,107.08) ; VRAM1.T9 221.11,97.52 v2(220.75,97.16) ; v2(214.01,84.23) 214.23,84.02 VRAM2.P9 ; VRAM1.D8 220.39,107.47 220.73,107.13 220.73,107.11 v2(220.76,107.07) ; VRAM2.M9 214.58,82.55 214.03,82.55 v2(214.04,82.55)
  TOP w0.381: C58.1 197.14,96.89 197.54,97.29 197.54,97.56 ; VRAM1.P9 221.13,99.45 v2(221.78,99.45) ; C48.1 195.83,97.59 v2(195.92,97.5) ; v2(214.21,109.66) 214.21,109.59 214.28,109.51 214.31,109.51 214.72,109.1 VRAM1.B1 ; R138.1 119.23,66.02 119.62,66.41 119.62,67.3 v2(118.98,67.93)
  TOP w0.406: EC33.1 19.04,59.34 18.58,59.8 EU3.3
  TOP w0.432: v2(113.32,68.59) 113.43,68.47 U3.5
  TOP w0.457: v2(186.3,88.53) 186.48,88.35 188.23,88.35 C135.2 ; R49.1 179.91,94.99 v2(180.27,94.63) ; C49.2 130.21,98.42 v2(129.82,98.03) ; PC12.2 v2(171.69,116.7) ; R111.1 v2(123.05,75.5) ; C302.1 147.68,37.81 v2(147.43,38.06) ; C70.2 v2(131.17,93.92) ; C71.2 v2(132.44,93.94) ; C295.2 156.83,38.24 156.7,38.37 v2(156.7,38.49) ; C241.2 179,44.06 v2(178.32,43.37) ; v2(158.83,38.11) 158.86,38.09 R201.1 ; R73.1 206.1,85.71 205.34,85.71 ; v2(122.64,113.63) 122.06,113.63 Q6.1 ; R13.1 122.84,111.83 v2(122.84,112.28) ; C39.2 179.03,99.22 v2(178.62,99.22) ; C232.2 149.21,43.57 v2(148.92,43.28) ; C227.1 v2(143.75,43.32) ; C301.1 144.13,37.81 v2(144.46,38.14) ; v2(227.21,79.59) 226.79,79.59 C170.2 ; v2(140.14,88.96) 140.17,88.94 140.78,88.94 C145.2 ; v2(218.27,117.56) 218.23,117.6 PC9.2 ; C292.2 155.68,38.29 v2(155.56,38.42) ; R86.1 v2(227.16,82.41) ; C131.1 154.61,90.04 154.17,89.6 v2(154.11,89.6) ; v2(137.34,98.03) 137.6,98.29 C51.2 ; R76.2 R72.1 v2(315.46,86.7) ; v2(215.86,119.82) 215.86,119.39 PQ2.1 ; C78.2 v2(137.52,93.89) ; v2(15.98,59.3) 16.49,59.8 EU3.8 EU3.3 ; C228.2 147.43,43.42 v2(147.38,43.37) ; v2(309.61,68.82) 309.71,68.92 310.42,68.92 310.58,69.08 310.82,69.08 311.07,69.33 311.07,69.33 311.32,69.58 EU2.3 ; C315.2 63.46,35.29 v2(64.32,35.29) ; C119.2 v2(141.71,90.92) ; C136.2 189.7,88.62 v2(189.7,87.64) ; C146.2 142.18,88.94 141.56,88.94 v2(141.54,88.96) ; C149.2 147.56,88.5 v2(148.08,89.03) ; v2(149.46,77.63) 150.18,77.63 R105.2 ; C143.1 137.06,88.89 v2(136.99,88.96) ; v2(211.03,76.92) 210.67,76.56 C177.1 ; v2(227.92,83.35) 227.72,83.55 C164.2 ; C35.1 v2(21.29,99.81) ; C103.1 v2(179.69,93.48) ; v2(211.39,82.84) 211.18,82.84 211.13,82.79 211.12,82.8 R85.1 ; C104.1 v2(180.83,93.51) ; C212.2 110.75,51.29 111.09,51.62 v2(111.51,51.62) ; C130.2 v2(151.42,89.65) ; C148.2 129.26,88.14 129.75,88.63 v2(129.75,89.39) ; v2(227.74,84.19) 227.11,84.82 C161.2 ; C82.2 127.47,94.68 v2(126.86,94.07) ; PC11.2 v2(224.01,118.15) ; v2(211.01,98.11) 210.51,98.11 C47.1 ; C107.2 v2(129.04,91.93) ; C52.2 142.09,98.29 v2(142.35,98.03) ; C97.2 v2(128.96,93.2) ; v2(114.66,50) 114.66,50.28 114.27,50.67 R153.1 ; C77.2 v2(136.25,93.89) ; C69.2 128.63,94.4 v2(129.14,93.89) ; v2(211.16,87.24) 211.16,86.98 210.51,86.34 C159.1 ; v2(159.27,116.01) 160.13,116.88 PC8.2 ; C248.2 178.95,43.04 178.62,42.71 v2(178.32,42.71) ; v2(141.13,93.92) 141.33,94.12 C74.2 ; v2(155.85,93.98) 155.84,93.97 155.84,93.97 155.7,93.83 C88.1 ; R107.2 R108.2 C190.2 155.84,74.94 156.29,74.48 v2(156.5,74.48) ; C108.2 v2(151.39,91.81) ; EU1.3 EU1.8 v2(16.24,77.46) ; v2(182.21,101.25) 182.16,101.2 C30.2 ; C231.2 145.65,43.39 144.89,42.63 v2(144.66,42.63) ; C153.2 152,88.68 v2(151.75,88.94) ; C29.2 210.49,102.34 211.04,102.89 v2(211.04,102.97) ; R150.1 107.86,51.08 v2(107.86,50.2) ; v2(146.46,91.02) 146.44,91.02 146.29,90.87 C126.2 ; C64.2 153.48,96.08 v2(154.24,96.84) ; C50.2 134.57,98.29 v2(134.83,98.03) ; C294.2 v2(149.59,38.16) ; v2(133.69,93.92) 133.71,93.94 C72.2 ; v2(187.9,78.29) 188.41,78.29 R99.2 ; C73.2 v2(140.06,93.97) ; C268.2 52.68,39.68 53.07,40.07 v2(53.07,40.04) ; PC4.1 v2(218.3,119.36) ; C152.2 v2(150.99,88.94) ; R57.2 v2(112.5,91.9) ; C144.1 138.83,88.89 v2(138.77,88.96) ; v2(126.78,95.52) 127.41,96.14 C62.2 ; C123.2 v2(129.03,90.68) ; v2(211.06,85.61) 210.95,85.61 C162.1 ; EU2.8 v2(313.67,69.58) ; C158.2 128.62,86.87 128.91,87.16 v2(128.91,87.46) ; C296.2 157.84,38.11 v2(157.91,38.18) ; v2(130.16,93.89) 129.9,94.14 C75.2 ; C132.2 v2(129.01,89.41) ; C95.1 v2(152.63,92.76) ; v2(211.16,105.9) 211.13,105.88 C26.2 ; C32.1 v2(21.29,101.08) ; v2(122.39,75.27) 122.18,75.47 122.18,75.91 R110.1 ; v2(227.08,85.84) 226.96,85.97 C160.2 ; R106.2 152.57,76.43 153.3,77.16 v2(153.3,77.41) ; C293.2 v2(145.91,38.11) ; C79.2 v2(138.79,93.92) ; C94.2 v2(141.64,93.46) ; PC10.2 v2(219.82,117.94) ; C76.2 v2(134.98,93.89)
  TOP w0.483: v2(20.48,80.66) 20.48,80.16 EC36.1 ; v2(126.96,113.75) 126.36,113.75 C197.2 ; EC35.1 v2(21.04,76.99)
  TOP w0.508: PC250.2 248.84,44.7 248.45,45.1 v2(248.45,45.3) ; v2(296.6,53.12) 296.18,52.7 C211.1 ; C539.1 133.46,88.91 v2(133.4,88.98) ; PC31.1 227.96,52.5 PR45.2 227.96,50.6 228.52,50.04 v2(228.85,50.04) ; v2(184.79,67.88) 185.24,67.43 C199.2 ; v2(224.77,75.7) 225.42,75.7 PC18.2 C188.2 ; PR427.2 v2(64.7,17.77) ; C31.1 v2(13.72,101.08) ; C276.2 297.24,38.47 v2(296.78,38.92) ; v2(18.22,64.35) 19.26,63.31 EC34.1 ; PC76.2 47.89,20.71 v2(48.5,21.32) ; v2(174.02,31.58) 174.02,31.86 173.6,32.29 PR81.2 PC53.2 ; C314.2 297.28,35.98 297.08,36.18 v2(296.96,36.18) ; EC6.2 215.48,31.97 v2(215.48,31.63) ; C253.1 59.57,42.28 59.59,42.26 v2(59.59,41.52) ; v2(224.09,93.15) 224.55,92.69 C98.1 ; PC19.2 230.83,71.22 v2(231.33,70.73) ; C269.2 182.79,39.36 v2(182.3,39.84) ; v2(72.61,24.89) 72.76,25.04 C399.2 ; PC66.1 145.3,26.64 v2(144.45,25.79) ; PC79.1 87.01,22.11 v2(86.75,22.11) ; R70.1 178.41,86.13 179.23,85.3 v2(179.79,85.3) ; R231.1 296.65,33.25 v2(296.65,34.12) 297.23,34.12 C322.2 ; v2(279.08,25.77) 279.08,26.35 278.65,26.78 Q26.1 ; v2(59.3,43.65) R483.2 59.31,44.37 v1(60.36,44.37) ; v2(286.49,39.86) 286.11,39.86 285.36,39.11 PC42.2 ; Q47.1 171.28,71.13 171.93,70.48 R519.2 172.45,71.79 v2(172.86,72.2) ; v2(56.22,41.31) 55.76,41.77 C258.2 ; v2(45.32,21.45) 45.96,20.81 PC75.2 ; R93.1 227.14,80.25 v2(227.25,80.37) ; v2(19.69,5.42) 19.03,6.08 C401.2 ; v2(246.22,28.83) 246.26,28.83 C535.2 ; v2(234.48,20.53) 234.93,20.08 PC82.2 ; R6.1 170.8,114.26 171.43,113.63 v2(171.84,113.63) ; C19.2 150.74,107.27 150.88,107.12 v2(150.88,106.72) ; v2(316.04,83.43) 315.65,83.04 R83.2 ; R276.2 v2(306.06,23.98) ; C273.1 298.99,38.59 v2(298.53,39.05) ; v2(197.44,22.64) 197.77,22.97 PC78.2 PC73.1 ; v2(112.38,88.81) 112.84,89.27 R61.2 ; v2(189.57,63.61) 188.83,62.88 188.83,62.52 Q16.1 ; PC14.2 178.73,117.57 v2(178.44,117.28) ; v2(68.94,41.26) 68.69,41.52 C265.2 ; C187.1 C175.1 ; R250.1 295.77,30.85 v2(295.92,31) ; C256.2 218.65,41.46 v2(218.6,41.41) ; Q1.1 159.6,127.65 v3(159.62,127.67) ; C252.2 v2(111.87,42.53) ; v2(223.93,99.81) 224.53,99.81 C37.2 ; PC39.2 278.75,40.5 v2(278.19,41.06) 278.65,41.52 PC38.2 ; C540.1 135.19,88.91 v2(135.12,88.98) ; PR76.2 129.61,32.41 v2(129.42,32.22) 129.11,32.53 PR79.2 ; C342.2 87.16,27.93 v2(86.9,27.67) ; v2(114.18,90.71) 114.66,91.19 R58.2 ; C395.2 v2(72.98,28.41) ; v2(174.33,115.18) 174.33,114.49 174.53,114.29 PC13.1 ; v2(188.22,42.96) 188.31,43.05 PC36.1 189.21,43.73 189.21,43.73 v1(189.21,44.18) ; v2(17.99,63.56) 17.77,63.34 17.77,62.88 C166.2 ; R17.2 158.68,109.71 v2(159.22,110.25) ; PC47.2 PR65.2 v2(51.16,32.63) ; v2(153.32,97.5) 153.3,97.52 C53.1 ; v2(250.93,37.83) 251.7,38.59 PC252.2 ; v2(33.89,39.53) 33.89,39.46 C279.2 ; v2(298.74,36.56) 298.85,36.45 C304.1 ; C11.2 v2(156.17,110.02) ; v2(180.42,87.59) 179.99,88.02 C139.1 ; v2(63.18,41.44) 62.73,40.99 C262.2 63.77,40.63 v1(63.77,40.63) ; v2(117.43,118.99) 117.31,118.87 PC6.2 ; v2(232.68,48.21) 233.06,48.59 PC254.2 ; PC20.2 229.34,69.84 v2(229.24,69.73) ; C111.1 177.81,91.81 v2(177.81,91.76) ; v2(166.31,38.01) 166.31,37.31 165.06,36.05 R207.1 ; C4.2 192.98,114.3 v2(192.98,114.34) ; v2(130.9,23.67) 129.98,23.67 PR107.2 ; C173.1 226.61,78.04 v2(227.06,78.04) ; C333.2 63.69,31.1 63.05,31.74 v2(63.05,32.02) ; v2(255.81,49.85) 256.04,49.85 256.75,49.14 PQ41.1 ; C250.2 227.72,43 v2(227.72,43.78) ; v2(224.04,100.87) 224.1,100.94 R31.1 ; v2(223.99,102.91) 224.4,102.91 224.6,103.1 R27.2 ; C344.1 191.63,29.63 191.47,29.78 v2(191.45,29.76) ; PR191.2 253.87,50.16 v2(254.24,49.8) ; v2(296.65,31.08) 296.68,31.1 C330.2 ; v2(298.75,34.26) 298.9,34.42 C321.2 ; PC51.2 188.82,33.3 188.56,33.56 188.53,33.56 v2(188.5,33.59) ; v2(224.11,96.65) 224.33,96.65 224.34,96.66 224.37,96.66 224.46,96.75 R41.1 ; C261.2 v2(303.13,41.77) ; C137.1 180.83,88.07 v2(180.88,88.02) ; R255.1 235.19,29.4 v2(235.85,30.06) ; R141.1 112.26,58.8 111.62,58.15 v2(111.62,57.77) ; C129.1 143.09,89.65 142.88,89.44 v2(142.88,88.96) ; v2(309.53,42.56) 308.99,42.56 C257.2 ; v2(295.02,42.7) 295.36,42.35 R528.2 ; C270.2 317.46,39.86 v2(317.08,40.25) ; C194.2 v2(117.3,71.61) ; v2(162.02,112.37) 162.02,112.57 Q5.1 ; v2(152.28,34.76) 152.28,36.31 C303.1 ; v2(258.38,49.34) 258.38,49.29 259.16,48.51 PC158.1 ; v2(57.49,19.24) 57.66,19.41 PR425.2 ; C360.2 v2(316.06,25.34) ; v2(178.93,74.79) 179.79,73.93 Q9.1 ; C193.1 174.35,74.48 v2(174.71,74.84) ; v2(261.6,36.31) 262.26,35.65 C536.2 ; v2(192.85,35.12) 192.85,35.17 192.82,35.14 192.82,35.09 192.83,35.1 PC46.1 ; C237.2 293.62,44.95 v2(293.81,45.15) 294.29,45.63 C220.1 ; C9.2 224.14,110.7 v2(224.06,110.63) ; R510.2 245.16,31.67 245.59,31.24 R504.2 R503.2 248.3,31.2 248.78,31.2 v2(248.93,31.36) ; EC1.2 148.26,118.09 148.01,117.84 v3(147.68,117.84) ; PR68.2 35.24,34.52 v3(35.24,35.5) ; PQ13.1 125.33,32.76 124.56,32 124.56,31.92 v2(124.54,31.9) 124.12,31.48 PQ12.1 ; PC58.1 52.31,25.69 v2(52.31,25.39) ; C12.1 v2(151.98,108.95) ; PR101.2 v2(94.47,26.05) ; R46.2 167.11,95.36 167.89,96.14 v2(167.89,96.35) ; C316.1 v2(231.25,34.02) ; PC67.1 236.24,26.56 235.95,26.28 v2(235.24,26.28) ; R164.2 v2(176.77,43.32) ; v2(123,28.36) 123.06,28.36 123.3,28.6 PC60.2 ; C66.1 150.47,95.33 v2(150.35,95.21) ; R454.2 276.47,31.05 v2(277,31.58) ; PR85.1 136.03,31.01 135.52,30.5 v2(135.52,29.74) ; C157.1 v2(226.31,87.59) ; v2(192.69,79.34) 192.78,79.25 R101.1 ; C218.2 178.54,48.84 177.28,48.84 v2(177.22,48.78) ; v2(180.32,78.73) 179.79,78.19 Q8.1 ; PR95.2 v2(33.94,28.42) ; EC38.1 308.76,65.38 v2(308.44,65.06) ; C176.1 226.81,77.2 v2(227.03,77.42) ; C90.1 v2(18.32,93.66) ; v2(197.57,20.53) 197.59,20.56 PC81.1 ; v2(144.66,30.49) 144.66,31.63 145.46,32.43 PQ15.1 145.49,32.6 142.81,32.6 142.64,32.43 PQ14.1 ; v2(314.73,29.08) 315.19,29.54 C341.2 ; C230.1 154.54,43.19 v2(154.67,43.06) ; C115.1 154.15,91.43 v2(153.7,91.88) 154.15,92.33 C102.2 ; v3(180.43,22.57) 179.99,23.01 PC77.2 ; C209.1 289.83,53.68 288.4,53.68 v2(288.32,53.76) ; v2(178.01,83.7) 178.67,83.04 C165.2 ; EC7.1 165.64,32.63 v2(164.96,31.94) ; v2(148.08,89.03) 148.83,88.28 C150.2 ; C63.2 145.27,95.97 v2(146.03,95.97) ; C13.1 v2(22.69,108.83) ; C398.2 v2(191.49,23.35) ; R112.1 124.57,75.96 v2(124.19,75.58) ; PC50.1 119.54,33.17 119.33,32.96 v2(119.21,32.96) ; v2(53.93,20.15) 53.74,19.96 PC241.2 ; v2(133.42,32.11) 133.42,32.92 ; 133.42,32.92 PC52.1 ; 133.42,32.92 PR74.2 ; C55.2 149.1,97.84 v2(149.39,98.13) ; C239.2 288.26,43.56 v2(288.27,43.55) ; C246.2 v2(262.86,38.98) ; PC43.2 v2(278.87,37.81) ; v2(211.06,100.34) 210.9,100.18 C33.1 ; v2(111.26,121.02) 111.49,121.02 111.75,120.75 SJ1.1 ; v2(53.73,19.24) 54.67,19.24 PQ21.1 ; v2(302.24,41.77) 302.09,41.62 C263.1 ; C67.2 149.32,95.35 v2(149.46,95.22) ; C490.2 276.21,46.72 276.59,46.34 v2(276.59,45.83) ; C300.1 140.44,35.55 v2(141.08,34.92) ; C5.1 v2(224.17,112.77) ; v2(298.76,30.57) 299.22,30.57 299.44,30.79 C335.1 ; v2(18.32,61.35) 18.28,61.35 C167.2 ; R10.2 120.46,114.55 v2(120.73,114.82) ; C127.2 147.3,90.66 146.95,91.02 v2(146.46,91.02) ; PC21.1 224.9,68.08 v2(225.76,67.22) ; C259.2 310.5,42.54 v2(310.5,42.63) ; v2(249.69,45.38) 250.12,45.38 250.2,45.3 PC251.2 ; C21.1 v2(224.14,107.17) ; PQ18.1 v2(93.23,22.74) ; Q33.1 v2(190.64,19.8) ; C207.1 v2(299.96,56.89) ; C254.2 v2(62.95,42.96) ; C116.1 167.09,91.17 167.11,91.2 v2(167.52,91.2) 167.54,91.18 C120.2 ; v2(160.56,38.72) 160.26,38.72 159.88,38.34 C297.2 ; PC64.2 45.11,23.44 v2(44.51,24.03) ; v2(241.03,40.85) 241.03,41.26 242.3,42.53 242.3,43.17 242.68,43.55 243.18,43.55 PC249.2 243.4,43.56 243.79,43.16 243.79,42.95 243.96,42.79 PU11.2 ; v2(241.69,54.88) 241.99,55.18 241.99,56.37 241.61,56.76 PR38.1 ; C208.1 290.89,54.29 v2(288.96,54.29) ; C60.1 178.29,97.88 178.65,98.23 v2(178.65,98.54) ; PC72.2 136.25,25.32 v2(136.25,25.34) ; v2(309.61,68.82) 309.79,68.64 EC37.1 ; v2(62.16,33.39) 62.6,33.83 R219.1 ; v2(180.12,83.68) 179.48,84.31 C163.2 ; v2(132.27,24.67) 132.27,24.7 132.66,24.31 PC74.1 ; C1.1 v2(173.48,125.31) ; v2(19.03,96.96) C45.2 ; PR434.1 249.61,40.83 v2(248.88,40.83) ; PQ8.1 v2(246.01,47.36) 245.86,47.21 PR59.2 ; C397.2 v2(190.24,23.35) ; PC253.2 v2(252.48,42.66) ; C23.2 v2(15.27,106.92) ; C278.2 321.51,38.73 v2(321.01,39.23) ; v2(49.51,39.91) 49,39.41 PC41.2 PC40.2 ; C361.1 v2(192.52,26.27) ; C34.1 v2(13.7,99.81) ; v2(169.98,92.11) 170.09,92.11 170.54,91.65 C122.2 C121.2 ; C87.2 23.25,93.79 v2(23.5,94.04) ; v2(307.35,42.89) 307.55,42.68 C255.1 ; R60.2 173.24,89.72 173.6,90.08 173.6,90.69 173.31,90.97 C117.1 174.05,91.17 v2(174.25,91.38) ; EC5.2 215.96,34.78 214.64,33.46 214.64,32.83 v2(214.51,32.7) ; v2(192.74,41.97) 193.05,41.67 193.2,41.67 PC37.2 ; C54.2 v2(179.46,96.76) ; C260.2 298.32,40.36 v2(298.26,40.3) ; v2(294.5,44.51) 294.5,43.32 C249.2 ; C240.2 291.8,43.58 v2(291.8,43.6) ; C327.1 v2(300.82,31.99) ; R24.1 v2(173.64,104) ; C359.1 306.08,26.91 v2(306.59,27.42) ; C319.1 v2(228.74,35.3) ; PQ22.1 v2(33.38,12.05) ; C168.2 v2(174.35,80.38)
  IN1 w0.508: v2(313.28,25.36) 313.28,27.84 314.52,29.08 v2(314.73,29.08)
  BOTTOM w0.152: v2(149.46,77.63) 149.61,77.78 U14.AY18
  BOTTOM w0.178: v2(120.79,90.77) 120.83,90.81 U14.Y63 ; U14.AB7 156.21,89.98 v2(156.38,90.16) ; U14.AY26 144.47,78.49 144.28,78.3 v2(144.28,78.28) ; v2(156.87,100.46) 156.7,100.3 156.63,100.3 156.47,100.14 156.17,100.14 U14.D8 ; v2(120.86,88.45) 120.99,88.58 121.5,88.58 U14.AD63 ; U14.AY22 147.18,78.8 146.69,78.32 v2(146.69,78.07) ; v2(143.5,102.13) 143.53,102.1 143.53,101.5 U14.A28
  BOTTOM w0.191: PQ24.3 123.47,123.39 ; PU9.41 111.3,117.36 PU9.29 ; v2(146.16,118.55) 145.99,118.72 PQ26.3
  BOTTOM w0.203: U14.AY11 153.77,78.16 153.3,77.69 v2(153.3,77.41) ; U13.AF8 188.44,103.58 188.86,103.16 188.86,101.82 U13.AC8 ; v2(159.14,82.15) 158.84,82.45 U14.AP3 ; PR130.2 211.32,123.64 v2(210.93,123.25) 210.43,122.75 PC102.2 ; v2(159.14,88.15) 158.84,88.45 U14.AD3 ; U14.F61 122.81,98.38 v2(122.52,98.68) ; U23.27 219.01,42.29 218.85,42.13 218.85,41.74 218.6,41.49 v2(218.6,41.41) ; U14.AY4 158.17,79.16 U14.AW4 ; v2(207.12,120.23) 207.35,120.46 PU8.12 ; v2(227.72,31.74) 227.72,31.48 227.49,31.26 U23.113 ; v2(224.04,29.04) 224.04,29.07 223.89,29.21 U23.122 ; U23.49 227.89,45.02 227.72,44.84 v2(227.72,43.78) ; U14.D2 159.09,100.06 158.4,100.06 v2(158.38,100.09) 157.66,100.09 U14.D5 ; U14.AC61 122.81,89.39 v2(122.52,89.69) ; U14.AY6 156.77,78.51 v2(156.88,78.4) ; U23.91 234.43,33.89 v2(234.32,34) ; U14.D59 124.24,99.52 124.77,99 U14.F58 ; U23.1 218.88,31.89 218.47,31.48 v2(218.09,31.48) ; U14.J63 121.19,96.81 v2(120.94,96.56) ; 160.33,81.08 160.62,81.08 v2(160.76,80.94) ; PR149.1 209.2,118.4 208.72,118.4 ; v2(184.7,100.93) 184.72,100.92 185.28,100.92 185.71,101.35 U13.AC5 ; v2(142.1,78.6) 142.1,79.38 U14.AY30 ; U14.AE5 157.68,87.96 v2(157.68,88.26) ; 208.72,118.4 v2(208.72,117.72) ; 208.72,118.4 PR148.2 ; U14.B56 U14.A56
  BOTTOM w0.229: v2(202.1,91.02) 202.07,90.99 201.32,90.99 U13.L23
  BOTTOM w0.254: VRAM2.T1 221.34,85.84 v2(221.34,86.19) ; v2(78.06,37.83) 78.14,37.83 78.26,37.95 CN14.51 ; v2(156.83,83.32) 156.8,83.35 156.72,83.35 U14.AN7 ; U14.E11 153.4,99.45 v2(153.32,99.45) 153.41,99.54 U14.D12 153.79,100.33 U14.C11 ; VRAM2.G9 214.25,78.42 v2(214.05,78.22) ; v2(195.44,86.83) 195.86,86.4 U13.E17 ; VRAM1.J2 215.51,103.47 v2(215.9,103.08) ; v2(123.82,98.68) 124.7,98.68 U14.F58 ; v2(77.96,42.79) 78.29,42.45 CN14.69 ; v2(153.81,102.32) 153.78,102.29 U14.A11 ; CN14.63 78.4,40.95 v2(77.99,41.36) ; v2(214.13,100.9) 214.13,100.89 214.31,101.07 VRAM1.M1 ; U14.B24 U14.A24 146.12,101.6 146.01,101.72 v2(146.01,102.04) ; v2(280.2,31.36) 280.2,31.63 280.5,31.94 CN11.19 ; PR133.2 170.38,122.64 ; 170.38,122.64 170.38,122.12 PC103.2 ; 170.38,122.64 v2(170.82,122.64) ; U14.AL10 154.55,84.96 v2(154.88,84.64) ; CN1.13 v2(23.38,100.45) ; v2(214.01,84.23) 214.59,84.23 214.72,84.1 VRAM2.P9 ; v2(214.1,74.15) 214.37,74.42 VRAM2.B9 ; U14.F20 148.87,98.56 148.01,98.56 v2(147.99,98.59) ; U14.D59 124.24,99.86 123.52,100.59 123.52,101.04 U14.B60 ; U14.B26 145.1,100.76 U14.C25 ; U14.AT13 152.91,82.05 153.22,82.05 v2(153.5,82.33) 153.68,82.16 153.8,82.16 U14.AR11 ; CN1.4 v2(23.53,104.95) ; v2(147.99,98.59) 147.54,98.14 U14.G22 ; v2(147.99,98.59) 147.91,98.67 U14.D21 ; v2(80.55,27.29) 80.21,26.95 79.28,26.95 CN14.7 ; U14.C14 152.62,100.14 U14.D14 152.62,99.94 v2(152.26,99.58) ; U14.AP20 149.02,82.55 v2(148.95,82.55) ; U14.AL26 144.62,84.82 v2(144.3,84.5) ; CN11.6 v2(274,31.46) ; v2(216.84,74.03) 216.7,74.03 216.32,74.41 VRAM4.B3 ; v2(305.62,70.29) 305.43,70.48 Q40.4 ; U14.AU16 U14.AV16 U14.AW16 U14.AY16 ; U13.AC26 203.51,101.56 v2(204.61,101.56) ; CN1.7 v2(23.6,103.45) ; U14.B20 148.63,100.75 U14.C20 148.63,99.72 v2(148.7,99.66) ; v2(78.09,43.95) CN14.75 ; U14.K1 v2(160.68,96.02) ; v2(157.79,82.92) 157.24,82.37 U14.AR5 ; CN14.1 79.28,25.45 80.36,25.45 v2(80.53,25.28) ; v2(45.32,21.45) 45.7,21.83 PR108.1 ; CN14.57 78.36,39.45 78.14,39.23 v2(77.96,39.23) ; v2(128.43,100.27) 128.57,100.4 U14.B52 128.46,100.87 128.46,101.3 U14.A52 ; VRAM4.A9 221.39,73.89 221.39,73.9 221.52,74.03 v2(221.52,74.05) 221.52,74.05 221.5,74.03 VRAM2.B1 ; v2(219.92,80.4) 219.99,80.33 220.3,80.02 VRAM2.J2 ; U14.V7 156.38,91.77 v2(156.38,92.07) ; VRAM3.E1 221.1,106.67 220.76,107.01 v2(220.76,107.07) 220.76,107.08 221.11,107.43 VRAM3.D1 ; R296.1 224.07,103.48 223.93,103.34 223.93,102.96 v2(223.99,102.91) ; v2(159.14,97.14) 159.14,97.25 U14.G3 ; v2(152.23,102.32) 152.11,102.2 U14.A14 ; v2(138.03,84.47) 138.21,84.47 U14.AL36 ; U14.G5 157.54,97.93 157.31,98.16 157.16,98.16 v2(157.06,98.26) 156.93,98.26 156.59,97.91 U14.G6 U14.G8 155.64,97.83 155.44,98.02 155.34,98.02 155.23,98.13 v2(155.22,98.13) ; Q40.1 304.13,74.47 v2(304,74.61) ; CN1.1 v2(23.48,106.45) ; U14.AY33 140.53,79.27 v2(140.53,78.81) ; v2(126.25,123.72) 126.88,124.34 126.88,124.55 PC85.2 ; U14.AP26 144.36,82.55 v2(144.3,82.55) ; CN11.25 283.5,33.5 v2(283.26,33.74) ; U14.U61 122.51,92.57 v2(122.51,92.68) ; v2(214.23,105.55) 214.71,105.07 VRAM1.G1 ; U14.H13 153.11,97.5 v2(153.32,97.5) ; v2(204.54,83.6) 204.01,83.07 203.49,83.07 203.39,83.17 203.33,83.17 ; U14.AK3 159.14,85.26 v2(159.14,85.15) ; CN11.16 279,31.94 278.6,31.53 v2(278.39,31.53) 278.39,31.86 278.5,31.96 CN11.15 ; CN11.9 275.5,31.74 v2(275.32,31.56) ; VRAM2.M9 214.16,82.42 214.03,82.55 214.03,82.55 v2(214.04,82.55) ; U14.AA1 160.61,90.02 v2(160.74,90.16) ; v2(212.38,58.87) 212.39,58.88 PR177.1 ; U14.AG1 v2(160.66,87.02) ; U14.P62 U14.P63 121.27,93.81 v2(121.04,94.04) ; v2(215.11,99.08) VRAM1.P1 ; U14.AP10 154.81,82.69 154.87,82.69 v2(154.9,82.66) ; U13.E22 v2(200.47,86.87) ; U14.E17 150.04,99.95 U14.D18 149.67,100.33 149.67,100.51 U14.C18 149.65,100.56 149.65,101.38 149.53,101.5 U14.A18 ; v2(221.56,82.79) 221.18,82.42 VRAM2.M1 ; VRAM1.T1 214.72,97.8 v2(214.16,97.24) ; U14.H17 150.57,97.47 150.27,97.47 U14.G18 149.7,97.82 v2(149.39,98.13) ; v2(78.09,33.45) CN14.33 ; U14.AL20 149.34,84.8 149.04,84.5 v2(148.95,84.5) ; v2(156.38,95.88) 156.21,95.7 U14.L7 ; CN11.12 v2(277,31.58) ; v2(123.91,42.58) 124.61,43.28 JDIM1.31 ; v2(157.72,101.18) 157.72,101.12 157.75,101.09 U14.B4 ; v2(161.04,93.41) 161.04,93.37 160.93,93.26 160.64,93.26 160.4,93.02 U14.T1 ; U14.D63 121.24,99.76 120.71,100.29 v2(120.71,100.32) ; VRAM4.F9 VRAM2.G1 ; v2(45.7,18.4) 46.08,18.78 PR112.2 ; VRAM2.P1 221.24,84.02 221.74,84.52 v2(222.03,84.52) ; v2(159.14,91.14) 159.14,91.26 U14.V3 ; JDIM1.72 v2(136.91,38.08) ; VRAM3.D8 215.51,107.44 v2(215.91,107.05) 215.53,106.67 VRAM1.E2 ; v2(161.43,43.37) 161.21,43.58 JDIM1.145 ; v2(78.04,36.43) 78.06,36.45 CN14.45 ; v2(159.14,94.14) 159.14,94.26 U14.N3 ; v2(198.51,82.51) 198.36,82.66 U13.B20 ; v2(127.31,98.03) 127.31,98.03 U14.F54 U14.D54 ; v2(214.08,86.55) 214.08,86.54 214.72,85.91 VRAM2.T9 ; CN1.10 v2(23.58,101.95) ; v2(202.1,91.02) U13.L25 ; v2(219.9,103.9) 219.9,103.86 220.29,103.47 VRAM1.J8 ; v2(70.52,29.7) CN14.18 ; v2(78.09,34.95) CN14.39
  BOTTOM w0.279: U15.3 174.52,74.3 174.71,74.48 v2(174.71,74.84)
  BOTTOM w0.305: v2(200.44,84.36) 200.8,84 U13.B23 ; v2(158.5,78.14) 158.5,78.37 158.22,78.66 U14.AY4 ; U13.AD13 192.6,102.2 U13.AE14 193.4,103.02 193.8,103.42 v2(193.8,103.42) ; VRAM3.F9 214.39,105.55 v2(214.23,105.55) ; U14.AM1 v2(160.67,84.03) ; U13.A2 183.45,83.2 v2(183.04,82.79) ; U14.D63 121.57,99.71 122.14,99.71 122.15,99.7 U14.D62 ; U18.14 25.44,58.61 v2(25.31,58.74) ; U13.U26 203.3,96.38 203.72,96.8 v2(203.69,96.8) ; v2(193.8,104.22) 193.8,104.22 193.4,103.82 U13.AF14 ; U13.AD12 191.74,102.2 v2(191.34,102.6) 190.94,103 U13.AE11 190.86,103.05 190.86,103.75 U13.AF11 ; v2(191.33,100.16) 191.32,100.16 U13.AB11 ; v2(192.98,86.01) 192.98,86 193.38,86.4 U13.E14 ; v2(204.54,83.6) 204.14,84 U13.B27 ; U13.B14 193.41,84.01 arc(193.37,84.01) 193.35,84.04 193.35,84.03 v2(192.97,84.42) ; U13.AD18 196.72,102.22 197.09,102.6 v2(197.12,102.6) 197.51,102.21 197.51,102.2 U13.AD19 ; U13.AF17 195.86,103.8 195.46,104.2 v2(195.46,104.2) ; VRAM3.G8 215.43,104.98 215.36,104.98 215.35,104.97 214.92,104.97 214.91,104.98 214.8,104.98 VRAM1.G1 ; VRAM4.D8 220.35,76.05 220.37,76.05 v2(220.71,76.39) 220.71,76.42 VRAM2.E2 ; v2(191.2,82.58) 191.2,82.79 191.13,82.86 191.13,82.91 191.11,82.93 191.11,83.47 191.13,83.49 191.13,83.71 191.11,83.73 191.11,83.81 U13.B11 ; U14.AV14 152.31,80.41 152.09,80.62 152.09,80.62 152.09,80.63 152.03,80.63 v2(151.9,80.76) ; v2(195.46,103.4) 195.46,103.4 195.86,103 U13.AE17 ; v2(219.9,78.8) 219.92,78.78 219.95,78.78 VRAM4.G8 ; v2(182.86,91.5) 182.95,91.42 U13.L2 ; v2(154.9,80.76) 155.25,80.41 U14.AV8 ; v2(195.49,100.16) 195.88,100.54 U13.AB17 ; U13.B1 182.09,84 v2(182.08,83.98) ; VRAM2.G1 221.41,78.12 v2(221.62,78.12) ; U13.AA7 187.52,99.78 187.52,100.34 187.6,100.41 U13.AB7 187.6,100.59 v2(188,101) 188.41,101.4 U13.AC8 ; U13.P5 185.9,93.91 v2(186.33,94.34) ; v2(195.46,102.6) 195.06,102.2 U13.AD16 ; v2(151.21,99.6) 151.21,99.63 151.24,99.6 151.24,99.49 U14.E17 ; U13.B17 195.88,83.41 v2(195.84,83.37) ; U13.B8 188.31,83.87 188.31,82.74 188.26,82.69 v2(188.28,82.69) ; v2(193.8,102.6) 194.19,102.2 U13.AD15
  BOTTOM w0.356: v2(122.44,38.75) 122.74,38.75 123.11,38.38 JDIM1.26 ; v2(132.14,43.01) 131.81,43.34 JDIM1.55 ; U14.F58 124.77,98.12 v2(124.7,98.05) 124.7,98.02 U14.H57 ; JDIM1.138 159.11,37.84 v2(158.83,38.11) 158.51,37.79 JDIM1.136 ; v2(219.89,108.69) 219.89,108.76 219.58,109.07 VRAM3.B3 ; JDIM1.173 169.61,43.21 170.16,42.66 v2(170.19,42.66) ; JDIM1.13 119.21,46.47 118.07,47.61 117.43,47.61 v2(117.41,47.59) ; JDIM1.190 v2(174.71,38.52) ; JDIM1.14 v2(119.51,38.09) ; v2(221.79,101.17) 221.69,101.07 VRAM1.M9 ; JDIM1.28 123.71,37.96 v2(123.78,38.04) ; v2(168.44,46.26) 168.18,46.26 167.81,45.89 JDIM1.167 ; JDIM1.3 116.21,43.6 116.28,43.53 116.28,43.14 116.68,42.73 v2(116.8,42.73) ; JDIM1.144 160.91,37.58 161.16,37.83 161.16,38.43 160.87,38.72 v2(160.56,38.72) ; v2(220.68,104.67) 220.71,104.67 VRAM1.G9 ; U13.V11 190.99,98.49 v2(190.99,98.67) ; U13.K11 U13.L12 ; JDIM1.195 176.21,43.72 176.61,43.32 v2(176.77,43.32) ; JDIM1.179 171.41,42.33 171.94,41.79 v2(172.09,41.79) ; v2(220.75,97.16) 220.8,97.16 220.82,97.13 221.06,97.37 221.06,97.82 VRAM1.T9 ; JDIM1.151 163.01,46.06 163.34,46.39 v2(163.91,46.39) 163.91,46.16 163.61,45.86 JDIM1.153 ; VRAM2.J8 215.92,80.42 v2(215.92,80.42) ; U13.U10 189.87,97.38 v2(189.87,97.4) ; v2(192.93,96.43) 192.41,95.9 U13.T13 191.93,95.43 191.93,95.39 v2(191.83,95.29) 191.44,94.9 U13.R12 ; JDIM1.170 168.71,37.93 v2(168.79,38.01) 168.94,38.01 169.31,37.64 JDIM1.172 ; v2(117.33,46.24) 117.61,46.24 118.01,45.84 JDIM1.9 ; v2(125.71,42.68) 125.99,42.68 126.41,43.1 JDIM1.37 ; v2(124.93,38.01) 124.91,37.99 JDIM1.32 ; JDIM1.25 122.81,43.34 122,42.53 v2(121.85,42.53) ; JDIM1.161 166.01,42.52 v2(165.97,42.48) ; JDIM1.133 157.61,45.83 158.07,46.29 v2(158.4,46.29) ; JDIM1.48 v2(129.71,38.08) ; JDIM1.44 v2(128.51,38.01) 128.96,38.01 129.11,37.86 JDIM1.46 ; v2(221.78,99.45) 221.13,99.45 VRAM1.P9 ; v2(215.9,76.43) 215.51,76.81 VRAM2.E8 ; JDIM1.8 v2(117.71,38.11) ; R290.2 134.81,106.64 v2(134.48,106.97) ; U13.R16 v2(194.86,94.36) U13.P15 ; v2(115.91,38.02) 115.91,38.04 115.91,38.03 JDIM1.2 ; v2(117.36,46.87) 118.02,46.87 118.61,46.28 JDIM1.11 ; JDIM1.65 134.81,46.08 134.22,46.67 v2(134.04,46.67) ; v2(155.56,38.42) 156.11,37.86 JDIM1.128 ; v2(165.49,41.36) 165.18,41.36 164.21,42.34 JDIM1.155 ; JDIM1.156 164.51,35.38 164.76,35.13 166.12,35.13 166.31,35.33 JDIM1.162 v2(166.31,38.01) ; U13.E5 186.04,86.45 186.44,86.85 v2(186.44,86.88) ; v2(160.16,42.66) 159.98,42.66 159.41,43.23 JDIM1.139 ; JDIM1.150 162.71,37.92 162.73,37.94 162.73,38.42 v2(162.87,38.57) ; JDIM1.20 v2(121.31,38.01) ; v2(156.22,42.56) 155.81,42.56 155.53,42.84 155.53,43.37 155.81,43.65 JDIM1.127 ; v2(172.91,38.04) JDIM1.184 ; VRAM1.E8 220.31,106.67 219.89,107.08 v2(219.95,107.08) ; RP13.4 RP13.2 138.1,106.56 138.62,107.07 v2(138.87,107.07) ; JDIM1.63 134.21,43.69 v2(133.89,43.37) 133.61,43.65 JDIM1.61 ; U13.N12 U13.M11 U13.L10 ; U13.L5 185.9,91.42 v2(186.32,91.83) ; v2(171.18,38.09) 171.11,38.02 JDIM1.178 ; VRAM1.B9 221.11,109.1 v2(221.52,109.51) ; U13.N14 192.85,92.35 v2(192.85,92.29) ; JDIM1.49 130.01,43.64 v2(130.31,43.34) ; JDIM1.60 v2(133.31,38.01) ; JDIM1.38 v2(126.71,38.08) ; v2(129.24,46.24) 128.51,46.24 128.21,45.94 JDIM1.43 ; v2(136.03,42.63) 136.53,42.63 136.89,42.99 136.89,43.57 136.61,43.85 JDIM1.71 ; v2(177.12,38.75) 176.82,38.75 176.51,38.44 JDIM1.196 ; JDIM1.19 121.01,43.67 120.68,43.35 120.68,42.96 120.23,42.51 119.79,42.51 v2(119.79,42.51) ; JDIM1.168 v2(168.11,38.01) ; JDIM1.66 v2(135.11,38.04) ; VRAM4.D1 214.67,76.02 214.18,76.5 v2(214.22,76.5) 214.22,76.5 214.26,76.54 214.44,76.54 VRAM4.E1 ; JDIM1.54 v2(131.51,38.07) ; JDIM1.134 v2(157.91,38.18)
  BOTTOM w0.376: PQ31.6 24.72,90.51
  BOTTOM w0.381: v2(202.1,86.85) 202.5,86.45 U13.E25 ; 214.18,109.64 214.18,109.67 214.38,109.87 VRAM3.A9 ; 214.18,109.64 214.18,109.63 214.72,109.1 VRAM1.B1 ; 214.18,109.64 v2(214.21,109.66) ; v2(201.32,100.9) 201.7,100.52 U13.AB24 ; 195.92,97.45 195.92,97.33 195.49,96.9 U13.U16 195.4,96.82 194.88,96.3 ; 195.92,97.45 196.37,97.9 U13.V17 v2(196.81,98.31) ; 195.92,97.45 v2(195.92,97.5) ; v2(186.3,88.53) 186.3,88.54 U13.H5 ; U13.P2 182.82,93.9 181.95,94.77 v2(181.95,94.8) ; 196.02,93.57 196.35,93.9 U13.P17 U13.R18 197.96,94.9 v2(198.03,94.83) ; 196.02,93.57 v2(196.02,93.46) ; 196.02,93.57 195.4,92.95 U13.N16 v2(194.9,92.4) U13.M15 U13.L14 193.11,90.61 v2(192.9,90.61) 192.4,90.12 U13.K13 192.34,89.9 191.96,89.52 v2(191.88,89.52) ; v2(203.84,98.92) 203.82,98.92 203.82,98.92 203.35,98.92 U13.Y26 ; U13.N14 U13.P15 ; v2(198.18,91.12) 197.96,90.9 U13.L18 U13.K17 196.37,89.9 196.17,89.7 v2(196.17,89.19) ; U13.H23 200.55,89.29 200.52,89.29 v2(200.47,89.34) ; v2(200.42,102.6) 200.4,102.6 U13.AD22 199.87,102.07 199.87,101.53 U13.AC22 ; 192.4,97.85 U13.V13 ; 192.4,97.85 192.44,97.85 v2(193.2,98.61) ; 192.4,97.85 192.01,97.46 ; U13.U18 U13.T17 v2(195.85,95.35) U13.R16 ; v2(187.97,86.83) 187.99,86.83 188.42,86.4 U13.E8 ; U13.AG2 182.99,104.6 v2(182.84,104.45) 182.7,104.31 U13.AF1 ; v2(198.78,104.2) 198.76,104.2 U13.AF20 ; U13.H2 183.42,89.02 182.82,89.02 182.74,88.94 v2(182.74,88.91) ; PC171.1 242.78,35.39 243.04,35.14 v2(243.04,34.66) ; 194.88,96.3 194.47,95.9 U13.T15 U13.R14 v2(192.92,94.42) U13.P13 192.25,93.9 v2(191.85,93.51) 191.4,93.05 U13.N12 ; 194.88,96.3 v2(194.88,96.23) ; U13.H25 202.5,88.92 v2(202.1,88.52) ; 192.01,97.46 v2(192.01,97.4) ; 192.01,97.46 191.4,96.85 191.4,96.89 ; v2(200.48,94.3) 200.88,93.9 U13.P23 ; U13.L10 189.41,90.9 189.41,90.86 v2(189.01,90.46) ; v2(201.27,104.2) 201.25,104.2 U13.AF23 ; U13.Y23 200.9,98.91 v2(201.28,99.29) ; v2(192.93,96.43) 193.4,96.89 U13.U14 193.89,97.39 ; 193.89,97.39 v2(193.89,97.6) ; 193.89,97.39 U13.V15 v2(194.4,98.59) ; U13.R12 191.4,94.89 190.41,93.9 U13.P11 v2(189.95,93.45) U13.N10 ; v2(198.78,103.4) 198.76,103.4 U13.AE20 199.16,102.2 U13.AD21 ; U13.R10 v2(189.87,95.37) U13.T11 190.45,95.95 190.45,96.17 190.79,96.51 ; v2(24.23,90.74) 24.49,90.74 24.72,90.51 ; 191.4,96.89 U13.U12 ; 191.4,96.89 191.17,96.89 190.79,96.51 ; U13.AF5 185.57,104.17 185.54,104.17 v2(185.52,104.2) ; 190.79,96.51 v2(190.79,96.46) ; v2(203.84,94.12) 203.62,93.9 U13.P26 ; v2(191.38,85.99) 191.33,85.99 190.93,86.4 U13.E11 ; U13.B5 v2(185.95,83.4) ; v2(201.33,96.81) 201.33,96.81 U13.U23 ; U13.Y2 183.5,98.87 183.3,99.07 v2(182.92,99.07) ; U13.U5 186.3,95.98 v2(186.33,95.98) ; U13.AB20 198.76,100.96 v2(198.78,100.96) ; PR174.2 21.83,88.81 v2(21.83,88.15) ; U13.E20 198.76,86 v2(198.76,85.98) ; U13.Y5 185.9,98.87 v2(186.3,99.27) ; U13.A26 203.33,83.17 ; v2(193.63,89.14) 193.64,89.14 U13.K15 194.4,90.03 v2(194.88,90.51) 195.01,90.51 U13.L16 195.57,91.07 195.74,91.07 v2(196.07,91.4) 196.4,91.73 U13.M17 U13.N18 197.4,92.91 v2(198.03,93.53) ; v2(182.21,101.25) 182.31,101.35 U13.AC2 ; U13.U2 v2(182.82,96.38) ; U13.L12 v2(191.86,91.37) U13.M13 192.46,91.9 v2(192.85,92.29) ; U13.E2 182.73,86.45 v2(182.72,86.46) ; U13.AB14 193.81,100.97 v2(193.81,100.98) ; U13.AG26 203.3,105.13 v2(203.03,105.4) ; R402.2 148.77,73.85 149.79,73.85 150.73,74.79 R397.2 ; 160.33,81.08 U14.AU1 ; 189.87,97.38 U13.V11
  BOTTOM w0.406: v2(21.06,57.19) 21.06,57.47 21.02,57.51 U17.1 ; C428.2 210.96,98.15 v2(211.01,98.11)
  BOTTOM w0.457: v2(312.3,86.4) 311.89,85.98 C436.2 311.89,84.75 312.11,84.53 C439.2 311.89,83.96 311.41,83.96 U2.46 311.61,83.17 R363.2 ; PC127.1 192.68,114.04 v2(192.98,114.34) ; v2(116.57,85.74) 117.17,85.74 R351.1 ; v2(180.12,83.68) 179.48,84.31 R361.1 ; U13.N10 189.32,92.82 188.55,92.82 187.82,93.56 v2(187.82,93.59) ; C427.2 210.77,103.25 v2(211.04,102.97) ; v2(211.49,79.41) 211.28,79.62 C447.2 ; v2(178.01,83.7) 178.06,83.65 178.09,83.65 178.41,83.33 R364.1 ; C444.2 310.83,79.92 310.12,80.63 U2.43 ; R367.2 311.62,82.16 U2.45 ; C435.2 308.22,85.7 307.78,86.14 v2(307.3,86.14) ; C434.1 210.69,85.97 v2(211.06,85.61) ; U2.44 311.77,81.01 C442.2 ; C426.2 C419.2 160.49,106.03 160.76,106.31 v2(160.93,106.31) ; PQ27.1 216.64,119.24 v2(216.64,119.85) ; Y2.4 188.88,76.11 v2(188.88,75.6) ; R366.1 227.04,82.53 v2(227.16,82.41) ; C440.2 v2(224.87,82.53) ; U2.42 308.34,80.89 C443.2 ; v2(156.98,106.69) 156.98,106.65 156.24,105.92 R289.2 ; C433.2 226.96,85.71 v2(227.08,85.84) ; v2(192.59,80.22) 192.5,80.22 C445.1 ; R285.1 202.24,108.95 201.24,109.95 v2(201.24,110.04) ; v2(189.85,80.76) 189.2,80.11 C446.1 ; C411.1 148.95,110.2 v2(148.7,110.45) ; R368.1 v2(227.25,80.37) ; v2(313.44,85.33) 313.84,84.93 C437.2 ; C415.1 160.36,108.11 v2(160.64,108.39) ; R369.1 v2(224.73,80.37) ; R355.1 179.76,85.33 v2(179.79,85.3) ; v2(33.49,36.08) 33.46,36.05 33.08,36.05 CN9.5 ; v2(211.06,100.34) 211.02,100.31 R302.1 ; v3(117.48,54.39) 117.43,54.44 115.45,54.44 114.71,53.7 JDIM1.207 115.52,52.7 116.45,53.63 v3(117.48,53.63) ; C438.2 308.34,84.44 U2.48 ; v2(164.3,74.36) 164.3,74.38 163.93,74.75 C458.1 ; R341.2 210.41,87.24 v2(211.16,87.24) ; PQ25.1 v2(214.92,121.8) ; R348.1 v2(179.79,86.47) ; v2(208.57,83.86) 208.57,83.96 208.4,84.13 R359.1 ; C432.1 v2(227.06,86.73) ; v2(180.42,87.59) 180.4,87.62 R342.1
  BOTTOM w0.508: C452.2 132.78,73.9 133.38,73.29 v2(133.38,73.27) ; R303.2 224.27,99.29 223.93,99.63 v2(223.93,99.81) ; R284.2 191.5,109.47 v2(191.5,109.73) ; EC18.1 298.43,52.18 v2(297.92,51.68) ; v2(255.89,41.26) 255.77,41.26 C486.2 ; C455.2 v2(136,73.67) ; v2(192.74,41.97) 192.59,41.97 192.42,42.14 C487.2 ; R335.2 177.65,88.76 177.57,88.67 177.17,88.67 177.05,88.55 v2(177.05,88.53) ; v2(116.59,98.36) 116.7,98.36 116.75,98.41 R306.2 ; C488.2 311.27,42.03 v2(311.87,42.63) ; R327.2 168.11,90.79 167.7,91.2 v2(167.52,91.2) ; C478.2 285.1,49.39 v2(285.99,48.5) ; L25.2 241.42,40.46 v2(241.03,40.85) ; v2(176.28,54.06) 176.67,54.45 178.05,54.45 179.81,52.7 JDIM1.208 ; R455.2 v2(314.92,42.54) ; v2(208.64,126.07) 208.01,126.07 PC84.1 ; C498.1 296.16,38.8 296.28,38.92 v2(296.78,38.92) ; v2(191.45,29.76) 191.37,29.76 191.37,29.81 191.34,29.84 C516.2 C517.2 ; v2(182.84,71.61) 183.14,71.3 C462.2 ; v2(29.24,56.91) 28.9,57.25 C474.2 ; v2(211.16,96.58) 210.96,96.38 210.96,96.35 210.59,95.99 C430.1 ; CN1.23 19.09,107.5 v2(18.65,107.94) ; v2(209.71,125.41) 209.65,125.47 PR124.2 ; v2(33.89,39.53) 33.89,39.28 34.5,38.67 C497.2 ; v2(297.47,28.21) 297.44,28.18 C519.2 ; v2(166.51,74.33) 166.87,74.7 C457.1 ; CN8.5 v2(249.76,37.88) ; C431.1 224.28,95.23 v2(224.17,95.34) ; ESD2.2 17.89,68.95 17.64,69.2 v2(17.64,69.46) ; v2(306.99,75.35) 306.99,76.95 R383.2 ; v2(198.31,34.4) 198.18,34.53 U24.4 ; v2(187.64,70.75) 186.98,70.09 C464.1 ; R400.1 190.61,74.7 190.9,74.99 v2(191.22,74.99) ; v2(298.58,54.18) 298.56,54.18 298.56,53.46 EC17.1 ; FAN2.3 238.75,57.6 v2(238.87,57.72) ; v2(162.24,76.19) 162.69,75.74 R389.2 ; C453.2 131.25,73.61 131.55,73.32 132.22,73.32 132.82,72.71 v2(132.88,72.71) ; 301.25,61.61 298.55,58.91 EC15.1 ; v2(134.65,73.27) 134.05,73.87 C451.2 ; v2(114.18,90.71) 114.18,90.79 114.57,91.18 R326.2 ; CN16.34 198.92,25.97 v2(198.56,26.33) ; R334.2 116.74,88.89 v2(116.65,88.98) ; C472.2 v2(237.85,61.02) ; v2(224.14,98.23) 224.33,98.04 C429.1 ; v2(203.61,38.95) 203.59,38.98 U21.4 ; v2(255.91,37.71) CN8.7 ; v2(294.09,39.64) 294.62,40.17 C494.2 ; v2(76.7,45.05) CN14.77 ; v2(33.66,42.07) 33.17,41.58 CN9.8 ; v2(185.89,76.54) 185.44,76.54 C448.2 ; ESD5.2 v2(295.51,49.01) ; C503.1 296.83,36.05 v2(296.96,36.18) ; C520.2 306.68,27.51 v2(306.59,27.42) 306.17,27 C523.2 ; v2(17.61,56.91) 17.89,56.63 ESD3.2 ; C505.1 296.03,33.5 v2(296.65,34.12) ; C423.2 139.24,106.02 139.25,106.03 v2(139.25,106.02) ; C471.2 22.92,59.72 22.92,59.19 v2(23,59.12) ; C484.1 242.05,46.6 v2(242.17,46.72) ; v2(237.42,36.23) 237.85,35.81 R469.2 239.29,35.81 Q43.1 ; v2(248.95,37.81) 248.85,37.91 247.91,37.91 CN8.8 ; C421.1 152.97,107.96 v2(151.98,108.95) ; v2(298.94,48.75) 298.55,49.14 EC20.1 ; R339.2 114.23,88 v2(113.8,88.43) ; 35.39,60.41 34.62,59.64 34.03,59.64 PC144.2 ; v2(151.93,116.38) 152.71,117.16 EC12.2 ; R382.2 R381.2 187.94,75.92 v2(187.96,75.9) ; v2(215.81,37.81) 215.81,37.43 216.39,36.84 C504.1 ; PC167.2 283.41,43.19 v2(282.18,43.19) ; v2(111.26,121.02) 111.56,120.72 PC105.2 ; v2(188.1,27.57) 187.9,27.38 CN15.4 ; v2(102.52,55.66) 102.17,55.66 101.83,55.33 FAN1.3 ; C461.2 177.85,72.83 v2(177.05,72.83) ; v2(109.13,27.06) 109.13,26.19 PC176.1 ; v2(297.92,44.56) EC22.1 ; R441.2 293.29,45.15 v2(293.81,45.15) ; v2(176.84,76.19) 176.84,76.01 177.15,75.7 Q36.1 ; v2(28.74,52.23) 28.57,52.07 R421.1 ; v2(287.82,36.51) 287.82,36.36 288.9,35.28 CN11.32 ; C450.2 160.51,76.19 v2(160.31,76.39) ; v2(114.28,85.74) 114.38,85.84 R353.2 ; EC16.1 298.55,56.75 298.48,56.68 v2(298.48,56.48) ; C422.2 144.29,105.35 v2(144.97,105.35) ; v2(199.5,56.63) 198.08,55.21 PQ37.1 ; v2(224.14,107.17) 224.52,107.55 C414.2 ; v2(180.32,79.67) 180.32,79.66 179.77,79.11 R377.1 ; R502.1 278.02,40.89 v2(278.19,41.06) ; Y1.2 142.69,108.28 v2(141.84,107.43) 141.84,107.4 141.02,106.58 Y1.4 ; R402.2 147.23,73.65 v2(146.67,74.22) ; v2(239.76,44.49) 239.69,44.56 R443.2 R448.2 ; C420.2 v2(224.09,106.29) ; v2(19.31,95.9) CN1.24 ; C524.2 v2(34.21,43.35) ; PC178.1 v2(153,25.67) ; v2(212.83,37.86) 212.86,37.88 R467.2 213.84,37.43 214.35,36.93 C502.2 ; CN11.33 273.27,37.15 274.05,37.93 274.05,39.05 273.06,40.04 ; v2(158.05,74.18) 158,74.23 158,74.81 R392.2 ; v2(167.32,101.65) 167.32,102.32 167.04,102.6 R300.1 ; v2(161.91,107.34) 161.77,107.47 R287.1 ; Q38.1 182.71,72.36 v2(182.8,72.27) ; v2(159.83,70.69) 159.91,70.77 160,70.77 160.38,71.16 160.38,71.7 160.71,72.03 161.25,72.03 161.78,72.56 R404.2 ; v2(80.53,25.28) 80.53,24.8 80.08,24.35 CN14.76 ; R330.2 v2(115.76,90.03) ; C456.2 135.36,73.37 135.7,73.04 v2(135.85,73.04) ; C460.2 156.58,74.03 156.5,74.11 v2(156.5,74.48) ; R387.1 R388.2 167.84,75.42 167.5,75.75 166.48,75.75 v2(166.45,75.78) ; EC21.1 298.05,45.83 297.8,46.09 v2(297.8,46.34) ; v2(201.3,49.87) 201.19,49.76 PC153.1 ; ESD1.2 v2(310.62,70.6) ; R319.2 v2(164.93,93.97) ; G2.1 195.07,18.66 v2(194.7,19.04) ; PC83.2 v2(175.24,125.21) ; CN1.22 v2(23.3,95.9) ; R114.1 v2(174.71,74.84) ; EC13.2 v2(165.21,90.66) 165.84,90.66 R328.2 ; C507.1 296.16,31.56 295.92,31.32 v2(295.92,31) 295.92,30.92 296.16,30.69 C512.2 ; CN11.34 v2(284.45,35.88) ; C407.2 224.52,111.09 v2(224.06,110.63) ; R401.1 189.52,74.34 v2(189.52,75.6) ; PQ29.1 v3(223.99,114.95) ; ESD6.2 26.54,14.08 26.33,13.87 26.33,13.81 v2(26.14,13.63) ; C473.1 v2(239,60.34) ; C454.2 v2(129.04,74.31) ; v2(192.69,79.34) 192.69,79.31 191.69,78.31 Y2.2 ; CN1.21 v2(24.45,108.57) ; v2(235.24,26.28) 234.72,25.76 CN16.33 ; CN11.31 v2(267.33,34.65) ; PQ34.1 v2(190.13,67.14) ; v2(177.53,104.05) 177.35,104.05 177.14,104.26 R295.2 ; C511.1 215.62,31.41 215.48,31.55 v2(215.48,31.63) ; ESD4.2 v2(294.88,55.49) ; v2(280.65,46.5) 281.03,46.88 C481.1 C482.2 ; EC19.1 v2(297.8,50.79) ; R325.1 v2(116.64,91.18)
  vias: v1(10.6,17.49) v1(11.43,50.91) v1(11.74,68.89) v1(12,88.4) v1(15.11,90.8) v1(15.24,90.35) v1(24.38,17.19) v1(29.68,17.74) v1(45.65,51.45) v1(63.99,37.42) v1(102.54,50.64) v1(121.07,125.74) v1(122.08,27.49) v1(124.35,118.58) v1(127.47,22.85) v1(128.41,118.73) v1(132.19,22.08) v1(136.08,110.78) v1(147.07,115.09) v1(149.58,125.48) v1(165.93,27.97) v1(170.15,24.43) v1(179.94,27.57) v1(196.84,60.24) v1(197.75,69.95) v1(201.7,70.81) v1(202.04,26.52) v1(206.43,113.09) v1(206.69,72.49) v1(214.63,23.64) v1(224.89,122.38) v1(228.99,23.05) v1(283.06,45.41) v1(289.72,49.47) v1(290.25,40.22) v1(300.05,45.88) v1(300.7,65.93) v1(301.03,62.16) v1(313.01,61.89) v1(313.77,62.92) v1(318.31,107.48) v1(318.55,60.14) v1(319,79.92) v1(319.74,102.56) v1(321.38,101.23) v2(0.99,101.39) v2(2.86,19.05) v2(3.11,104.71) v2(3.98,99.51) v2(4.09,88.9) v2(5.56,67.59) v2(5.65,51.78) v2(5.77,85.63) v2(5.77,69.81) v2(6.18,16.23) v2(7.68,50.2) v2(8.27,88.93) v2(8.26,51.95) v2(8.42,19.07) v2(9.8,99.41) v2(9.89,67.5) v2(10.09,69.33) v2(10.27,51.32) v2(11.02,91.98) v2(11.05,95.69) v2(11.44,86.12) v2(11.84,67.4) v2(12.1,6.67) v2(12.18,13.6) v2(12.47,108.74) v2(12.68,64.91) v2(12.68,53.91) v2(12.66,50.2) v2(12.81,82.84) v2(13.06,69.84) v2(14.17,6.77) v2(14.41,53.71) v2(14.71,69.07) v2(14.87,4.72) v2(15.2,56.02) v2(15.17,54.93) v2(15.4,82.97) v2(15.38,57.9) v2(15.93,84.92) v2(16.01,83.68) v2(16.04,82.99) v2(16.15,51.47) v2(16.72,104.81) v2(17.31,106.09) v2(17.55,110.33) v2(18.06,102.96) v2(18.27,81.09) v2(19.85,110.4) v2(19.82,1.04) v2(21.45,75.81) v2(21.42,51.47) v2(21.67,103.77) v2(21.8,76.47) v2(21.8,64.65) v2(21.93,66.79) v2(22.44,58.81) v2(22.76,103.65) v2(23.03,19.1) v2(23.56,110.37) v2(24.01,64.55) v2(24.16,54.91) v2(24.44,61.35) v2(24.8,64.15) v2(24.9,1.04) v2(25.03,63.56) v2(25.1,61.35) v2(25.1,56.81) v2(25.1,55.64) v2(25.51,62.44) v2(25.69,56.22) v2(25.99,108.21) v2(25.97,103.8) v2(26.02,96.01) v2(25.98,89.72) v2(25.98,83.06) v2(26.17,62.44) v2(26.27,56.81) v2(26.27,55.64) v2(26.88,76.42) v2(27.2,50.3) v2(27.77,19.16) v2(28.86,55.46) v2(29.19,69.94) v2(29.98,1.04) v2(32.06,49.21) v2(32.19,22.36) v2(33.38,63.12) v2(35.06,1.04) v2(37.28,13.44) v2(37.28,8.36) v2(38.65,15.65) v2(38.59,3.67) v2(39.46,57.06) v2(41.66,28.31) v2(41.79,27.29) v2(42.27,54.98) v2(42.91,54.6) v2(43.54,54.22) v2(43.73,15.65) v2(44.18,53.83) v2(44.81,53.58) v2(45.45,53.2) v2(47.58,52.43) v2(48.81,15.65) v2(53.89,15.65) v2(54.69,50.4) v2(56.72,39.13) v2(56.7,37.02) v2(57.77,38.09) v2(57.95,34.54) v2(58,30.75) v2(58.83,39.13) v2(58.83,37.02) v2(58.97,15.65) v2(59.36,34.17) v2(60.82,30.95) v2(63.23,39.33) v2(63.2,29.7) v2(63.53,49.83) v2(63.51,36.44) v2(64.05,15.65) v2(64.17,36.46) v2(69.13,15.65) v2(70.85,50.56) v2(71.72,24.89) v2(72.1,24.26) v2(73.54,31.81) v2(74.4,16.5) v2(75.09,27.9) v2(75.51,51.7) v2(77.15,37.12) v2(77.96,16.99) v2(80.74,29.08) v2(81.38,29.08) v2(81.85,54.49) v2(82.55,16.64) v2(85.86,15.61) v2(86.67,57.86) v2(90.94,15.61) v2(91.02,62.55) v2(95.49,71.13) v2(96.02,15.61) v2(97.92,76.61) v2(100.73,84.32) v2(101.1,15.61) v2(102.87,92.75) v2(103.51,15.69) v2(103.68,108.76) v2(103.76,121.21) v2(103.76,115.05) v2(103.81,100.51) v2(103.89,127.77) v2(107.95,15.73) v2(113.03,15.73) v2(116.58,127.69) v2(118.11,15.73) v2(118.22,28.28) v2(118.97,28.28) v2(119.65,28.28) v2(120.29,28.3) v2(121.01,86.88) v2(120.99,83.65) v2(120.98,28.28) v2(121.07,85.72) v2(121.08,82.36) v2(121.65,28.3) v2(122.31,28.33) v2(122.52,95.68) v2(122.52,15.72) v2(122.63,84.53) v2(123.7,82.23) v2(123.79,95.67) v2(123.82,94.18) v2(123.81,92.69) v2(123.82,91.19) v2(123.9,127.61) v2(124.03,86.34) v2(124,78.5) v2(124.29,84.5) v2(124.28,83.2) v2(124.28,81.9) v2(124.52,96.4) v2(124.47,91.19) v2(124.54,88.33) v2(125.24,84.5) v2(125.24,82.55) v2(125.24,81.9) v2(125.31,78.46) v2(126.27,100.27) v2(126.63,80.23) v2(126.68,39.36) v2(127.14,84.5) v2(127.14,82.55) v2(127.62,78.23) v2(127.6,15.72) v2(128.04,84.5) v2(128.09,83.24) v2(128.81,41.77) v2(128.99,84.5) v2(129.25,127.63) v2(129.16,78.09) v2(129.57,87.44) v2(129.75,39.41) v2(129.94,81.92) v2(130.52,24.91) v2(130.73,85.89) v2(130.74,29.04) v2(130.77,27.55) v2(130.77,24.33) v2(130.87,82.56) v2(131.02,101.94) v2(131.25,100.27) v2(131.18,24.86) v2(131.85,85.89) v2(131.81,83.88) v2(131.85,80.11) v2(132.32,98.03) v2(132.27,29.02) v2(132.27,27.6) v2(132.36,86.93) v2(132.68,15.72) v2(132.8,84.56) v2(132.8,83.91) v2(133.41,80.79) v2(133.42,80.11) v2(133.74,100.27) v2(133.74,84.62) v2(133.79,102.07) v2(133.75,83.97) v2(133.75,81.9) v2(134.64,85.89) v2(134.71,83.25) v2(134.98,80.8) v2(135,80.11) v2(135.52,105.47) v2(135.52,102.26) v2(135.59,84.49) v2(135.62,83.2) v2(135.68,85.9) v2(136.28,100.29) v2(136.47,86.68) v2(136.56,80.81) v2(136.57,80.11) v2(136.69,105.45) v2(136.69,103.52) v2(137.12,82.55) v2(137.76,15.72) v2(138.01,82.06) v2(138.06,82.69) v2(138.13,80.79) v2(138.14,80.08) v2(138.23,102.19) v2(138.64,103.11) v2(138.77,100.2) v2(139.02,83.2) v2(139.07,86.68) v2(139.71,80.76) v2(139.72,80.11) v2(139.78,104.43) v2(139.85,98.03) v2(139.87,85.87) v2(139.98,84.56) v2(139.98,81.96) v2(140.1,127.66) v2(140.9,85.8) v2(140.93,83.2) v2(141.28,100.29) v2(141.71,40.07) v2(141.71,38.72) v2(142.12,41.31) v2(142.38,85.89) v2(142.39,82.55) v2(142.64,15.62) v2(142.97,86.68) v2(143.19,38.67) v2(143.29,80.23) v2(143.81,100.26) v2(144.52,127.74) v2(144.51,39.48) v2(144.86,106.01) v2(144.86,98.03) v2(145.14,110.81) v2(145.25,109.74) v2(145.57,86.68) v2(145.88,40.68) v2(145.98,39.41) v2(146.13,120.03) v2(146.21,107.2) v2(146.2,85.89) v2(146.19,85.13) v2(146.2,84.5) v2(146.2,83.2) v2(146.32,100.26) v2(146.57,121.27) v2(146.95,120) v2(146.95,39.2) v2(147,103.92) v2(147.6,86.02) v2(147.71,121.27) v2(147.73,119.29) v2(147.71,118.55) v2(147.72,15.62) v2(147.76,119.98) v2(147.94,95.95) v2(147.9,94.31) v2(148.27,86.02) v2(148.42,80.23) v2(148.8,103.97) v2(149.6,127.71) v2(149.56,91.72) v2(149.59,90.54) v2(150.22,106.72) v2(150.25,88.91) v2(150.66,38.77) v2(150.81,85.89) v2(150.91,103.34) v2(151.44,90.79) v2(151.54,83.7) v2(151.58,82.32) v2(152.13,42.68) v2(152.1,41.43) v2(152.8,15.62) v2(152.89,88.94) v2(153.29,95.23) v2(153.53,84.31) v2(153.58,23.84) v2(154.11,93.23) v2(154.11,88.61) v2(155.03,127.66) v2(155.92,15.57) v2(156.19,41.24) v2(156.93,108.67) v2(158.76,40.4) v2(158.91,15.64) v2(160.2,70.18) v2(161.81,40.35) v2(161.83,39.05) v2(162.11,127.71) v2(163.99,15.64) v2(166.19,127.77) v2(166.77,15.73) v2(167.35,27.86) v2(168.99,41.26) v2(168.97,40.47) v2(169.91,38.8) v2(171.18,38.82) v2(172.02,28.61) v2(171.99,27.24) v2(172.64,127.66) v2(172.83,39.33) v2(172.88,27.95) v2(173.36,43.32) v2(173.44,42.05) v2(173.72,28.59) v2(173.8,27.6) v2(174,47.71) v2(174.84,40.47) v2(174.91,55.38) v2(176.56,93.13) v2(177.15,66.08) v2(177.15,52.41) v2(178.02,16.18) v2(178.19,104.02) v2(178.3,127.74) v2(178.39,108.47) v2(178.57,106.62) v2(178.67,27.21) v2(178.93,109.74) v2(179.34,27.2) v2(181.52,39.15) v2(182.05,38.67) v2(183.1,16.18) v2(184.06,80.4) v2(184.06,79.77) v2(186.49,127.74) v2(187.94,95.13) v2(188.1,92.14) v2(188.18,16.18) v2(188.78,98.39) v2(191.22,74.28) v2(191.27,107.53) v2(191.78,107.96) v2(191.82,74.44) v2(192.11,74.99) v2(193.26,16.18) v2(193.44,127.69) v2(198.34,16.18) v2(199.16,127.69) v2(199.22,108.93) v2(199.19,108.31) v2(202.9,26.86) v2(202.93,21.83) v2(203.42,16.18) v2(204.4,127.63) v2(205.01,29.15) v2(206.05,29.15) v2(206.82,49.67) v2(206.84,49.01) v2(206.84,48.32) v2(208.01,121.75) v2(208.5,16.18) v2(210.16,127.71) v2(211.36,35.6) v2(213.58,16.18) v2(215.23,127.7) v2(217.23,22.62) v2(217.27,78.27) v2(217.64,105.78) v2(217.94,22.62) v2(218.6,22.64) v2(218.66,16.18) v2(219.26,22.62) v2(219.95,22.62) v2(221.15,23.63) v2(221.84,23.63) v2(223.25,23.65) v2(223.74,16.18) v2(223.96,23.63) v2(224.7,76.34) v2(224.72,74.38) v2(225.08,72.49) v2(225.34,127.71) v2(226.09,22.67) v2(226.28,124.97) v2(226.41,118.31) v2(226.36,111.76) v2(226.38,104.78) v2(226.36,98.38) v2(226.75,22.67) v2(227.01,92.51) v2(228.01,87.98) v2(228.82,16.18) v2(230.07,81.48) v2(232.15,75.84) v2(233.9,16.18) v2(234.31,71.05) v2(238.86,63.02) v2(238.98,16.18) v2(240.28,18.59) v2(241.16,21.65) v2(242.37,58.7) v2(242.38,27.98) v2(243.7,27.93) v2(244.71,22.14) v2(247.79,54.7) v2(247.9,24.13) v2(252.98,24.13) v2(253.42,52.2) v2(254.44,40.3) v2(255.87,39.58) v2(256.98,40.19) v2(258.13,23.72) v2(259.01,50.59) v2(260.54,22.04) v2(262.8,28.97) v2(263.23,33.44) v2(263.2,31.99) v2(264.02,27.76) v2(264.9,49.91) v2(266.23,26.94) v2(266.66,35.27) v2(266.66,34.63) v2(267.14,31) v2(267.24,43.37) v2(267.19,42.07) v2(267.17,29.83) v2(267.33,35.28) v2(267.42,33.79) v2(267.39,25.46) v2(268.84,43.34) v2(268.84,42.15) v2(268.94,40.42) v2(271.28,49.99) v2(271.86,34.43) v2(273.01,33.59) v2(273.64,50.15) v2(274,35.06) v2(274,25.59) v2(274.89,34.25) v2(275.59,22.22) v2(276.28,38.9) v2(276.52,25.67) v2(276.7,50.67) v2(276.67,38.26) v2(279.46,22.21) v2(281.59,25.94) v2(282.18,43.83) v2(282.2,42.56) v2(282.18,40.19) v2(282.57,52.49) v2(285.91,25.94) v2(285.94,25.31) v2(286.77,30.69) v2(286.98,41.97) v2(288.47,55.62) v2(289.03,48.63) v2(289.03,47.99) v2(289.03,47.36) v2(289.66,47.37) v2(289.8,48.75) v2(289.8,48.12) v2(290.29,47.73) v2(290.41,48.54) v2(290.36,47.07) v2(291.47,40.75) v2(293.05,59.31) v2(293.43,51.43) v2(293.81,47.71) v2(296.95,63.57) v2(298.81,46.47) v2(299.95,68.34) v2(300.8,62.85) v2(301.48,66.03) v2(301.56,65.39) v2(302.21,73.71) v2(302.24,66.79) v2(302.75,67.3) v2(303.78,80.56) v2(303.94,36.89) v2(304.01,86.78) v2(304,32.7) v2(304.07,105.65) v2(304.07,92.61) v2(304.78,60.82) v2(304.8,22.13) v2(304.86,96.47) v2(305.11,35.62) v2(305.42,60.82) v2(305.63,101.26) v2(305.6,67.85) v2(306.08,80.58) v2(306.61,108.72) v2(307.02,64.88) v2(307.12,67.7) v2(307.64,64.86) v2(307.78,72.96) v2(307.93,70.12) v2(308.17,64.5) v2(308.64,36.84) v2(308.64,34.48) v2(308.64,32.22) v2(309.61,75.3) v2(309.66,73.49) v2(309.88,22.13) v2(312.01,24.87) v2(312.17,73.7) v2(312.28,63.23) v2(312.28,62.6) v2(312.28,61.96) v2(312.91,74.51) v2(313.04,63.23) v2(313.04,62.6) v2(314.74,93.41) v2(315.32,90.59) v2(316.49,108.58) v2(317.43,75.34) v2(317.39,63.78) v2(318.03,41.76) v2(318.89,77.55) v2(320.59,95.31) v2(320.72,84.26) v2(321.06,81.13) v2(321.23,108.69) v2(321.19,98.41) v2(321.91,58.69) v2(322.15,40.69) v2(323.96,77.47) v2(324.12,61.82) v2(324.7,98.46) v2(324.83,80.98) v2(325.64,59.11) v2(326.15,40.9) v2(326.5,108.71) v2(327.78,105.61) v2(327.78,100.53) v2(327.84,60.24) v2(327.81,39.08) v2(327.82,18.9) v2(327.87,78.91) v2(327.92,25.37) v3(27.67,16.91) v3(27.67,16.09) v3(28.53,16.94) v3(28.48,16.14) v3(29.26,16.9) v3(29.26,16.12) v3(30.04,16.93) v3(30.04,16.15) v3(34.65,41.11) v3(34.65,40.31) v3(35.06,39.66) v3(35.16,36.23) v3(35.42,41.11) v3(35.42,40.31) v3(35.67,36.82) v3(36.13,35.67) v3(36.33,36.44) v3(98.99,71.92) v3(98.99,71.06) v3(99.17,72.81) v3(99.83,71.89) v3(99.88,71.03) v3(99.96,72.81) v3(102.85,49.9) v3(103.49,50.53) v3(119.03,116.8) v3(119.49,116.22) v3(119.92,116.8) v3(120.18,125) v3(120.61,117.87) v3(120.61,117.05) v3(120.61,116.22) v3(120.63,23.99) v3(121.34,117.05) v3(121.34,116.22) v3(121.37,117.79) v3(121.39,23.99) v3(121.93,125.07) v3(122.11,117.82) v3(122.08,117.05) v3(122.08,116.22) v3(122.11,24.37) v3(122.28,120.76) v3(122.59,23.61) v3(122.69,125.07) v3(122.69,120.05) v3(122.69,119.32) v3(122.69,118.55) v3(122.84,117.84) v3(122.94,24.34) v3(123.17,120.76) v3(123.27,123.86) v3(123.43,120.03) v3(123.43,119.29) v3(123.43,118.53) v3(123.4,23.53) v3(123.45,125.07) v3(123.58,117.82) v3(123.81,24.22) v3(124.27,23.56) v3(125.05,23.63) v3(127.08,117.13) v3(127.36,117.87) v3(127.82,117.13) v3(128.1,117.87) v3(128.36,22.22) v3(128.56,117.13) v3(128.84,117.87) v3(129.29,117.13) v3(129.57,117.87) v3(130.27,127.56) v3(130.51,111.24) v3(130.49,110.5) v3(131.01,127.56) v3(131.75,127.56) v3(132.37,111.29) v3(132.39,110.48) v3(132.48,127.56) v3(132.98,21.92) v3(133.24,127.56) v3(133.36,22.75) v3(133.89,23.33) v3(133.87,22.04) v3(133.98,127.56) v3(134.35,22.73) v3(134.58,21.69) v3(134.72,127.56) v3(134.86,111.31) v3(134.86,110.53) v3(135.03,23.33) v3(135.04,22.3) v3(135.45,127.56) v3(135.65,22.73) v3(135.7,21.71) v3(136.19,127.56) v3(136.95,127.56) v3(137.42,111.36) v3(137.42,110.64) v3(137.69,127.56) v3(138.43,127.56) v3(139.16,127.56) v3(140.34,117.84) v3(140.34,117.08) v3(140.85,25.67) v3(141.08,117.84) v3(141.08,117.08) v3(141.36,25.04) v3(141.82,117.84) v3(141.82,117.08) v3(141.87,25.67) v3(142.38,24.91) v3(142.89,25.67) v3(143.39,24.91) v3(143.78,25.67) v3(144.99,115.86) v3(145.78,116.7) v3(145.78,115.94) v3(146.11,119.32) v3(146.16,123.48) v3(146.16,122.74) v3(146.16,122.01) v3(146.16,117.84) v3(146.59,116.67) v3(146.62,115.91) v3(146.9,123.48) v3(146.9,122.74) v3(146.9,122.01) v3(146.95,118.58) v3(146.9,117.84) v3(146.97,119.32) v3(147.33,116.67) v3(147.35,115.91) v3(147.68,123.56) v3(147.68,122.8) v3(147.68,122.03) v3(148.06,116.67) v3(148.09,115.91) v3(148.45,123.56) v3(148.83,116.67) v3(148.85,115.91) v3(152.43,24.65) v3(152.84,23.86) v3(153.17,24.65) v3(156.73,16.15) v3(157.26,127.67) v3(157.49,16.15) v3(158.05,127.67) v3(158.78,127.67) v3(160.36,127.67) v3(161.15,127.67) v3(164.1,26.56) v3(164.1,25.8) v3(164.1,25.04) v3(164.86,26.56) v3(164.86,25.8) v3(164.86,25.04) v3(165.75,20.98) v3(165.75,20.21) v3(165.75,19.45) v3(165.75,18.69) v3(165.84,119.82) v3(165.87,120.56) v3(166.4,123.96) v3(166.51,20.98) v3(166.51,20.21) v3(166.51,19.45) v3(166.51,18.69) v3(166.61,120.56) v3(167.14,123.96) v3(183.46,126.36) v3(183.81,125.69) v3(184.21,126.36) v3(184.56,125.7) v3(184.97,126.36) v3(185.32,125.71) v3(185.71,126.35) v3(186.06,125.72) v3(186.47,126.35) v3(186.83,125.72) v3(197.82,61.07) v3(198.18,58.03) v3(198.59,61.07) v3(198.92,58.03) v3(199.12,121.14) v3(199.3,69.53) v3(199.32,61.07) v3(199.65,58.03) v3(200.01,121.14) v3(200.06,61.07) v3(200.16,69.51) v3(200.44,58.03) v3(200.85,61.07) v3(200.9,121.02) v3(200.9,119.37) v3(200.9,118.22) v3(201.02,120.26) v3(201,69.51) v3(201.66,119.37) v3(201.79,121.02) v3(201.79,118.6) v3(201.84,69.51) v3(201.91,120.26) v3(202.04,49.24) v3(202.07,48.4) v3(202.07,47.66) v3(202.55,119.37) v3(202.67,121.02) v3(202.67,120.26) v3(202.8,49.52) v3(202.78,48.7) v3(202.78,47.97) v3(202.78,47.23) v3(203.16,70.78) v3(203.54,49.44) v3(203.54,48.7) v3(203.54,47.97) v3(203.54,47.23) v3(203.56,121.14) v3(203.97,71.54) v3(203.97,70.78) v3(204.28,49.44) v3(204.28,48.7) v3(204.28,47.97) v3(204.28,47.23) v3(204.83,115.35) v3(204.83,72.27) v3(204.83,71.51) v3(204.83,70.75) v3(204.86,73.01) v3(205.01,49.44) v3(205.01,48.7) v3(205.01,47.97) v3(205.01,47.23) v3(205.6,115.35) v3(205.67,72.27) v3(205.67,71.51) v3(205.67,70.75) v3(205.77,47.38) v3(206.05,114.69) v3(206.05,113.93) v3(206.38,115.35) v3(206.51,71.51) v3(206.51,70.75) v3(206.56,47.38) v3(206.69,114.29) v3(207.3,47.38) v3(208.14,47.38) v3(212.71,47.2) v3(212.73,46.47) v3(217.91,48.02) v3(218.7,48.02) v3(219.44,48.02) v3(220.18,48.02) v3(223.27,48.91) v3(223.27,48.17) v3(224.01,48.91) v3(224.01,48.17) v3(224.75,48.91) v3(224.75,48.17) v3(225.43,51.17) v3(225.53,50.41) v3(225.53,49.67) v3(225.53,48.93) v3(225.53,48.17) v3(226.17,51.17) v3(226.27,50.41) v3(226.27,49.67) v3(226.27,48.93) v3(226.27,48.17) v3(226.91,51.17) v3(227.01,50.41) v3(227.01,49.67) v3(227.01,48.93) v3(227.01,48.17) v3(227.77,49.67) v3(227.77,48.93) v3(227.77,48.17) v3(228.49,48.23) v3(229,48.77)
