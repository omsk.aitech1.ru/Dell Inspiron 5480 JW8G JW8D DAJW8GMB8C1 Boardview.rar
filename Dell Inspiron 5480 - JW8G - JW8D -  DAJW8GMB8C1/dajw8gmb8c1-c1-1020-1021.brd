# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
QFN24-4X4-5-25P
  rect 0.279x0.991 smd: 1(-1.25,-2.1) 2(-0.75,-2.1) 3(-0.25,-2.1) 4(0.25,-2.1) 5(0.75,-2.1) 6(1.25,-2.1) 13(1.25,2.1) 14(0.75,2.1) 15(0.25,2.1) 16(-0.25,2.1) 17(-0.75,2.1) 18(-1.25,2.1)
  rect 0.991x0.279 smd: 7(2.1,-1.25) 8(2.1,-0.75) 9(2.1,-0.25) 10(2.1,0.25) 11(2.1,0.75) 12(2.1,1.25) 19(-2.1,1.25) 20(-2.1,0.75) 21(-2.1,0.25) 22(-2.1,-0.25) 23(-2.1,-0.75) 24(-2.1,-1.25)
  rect 2.591x2.591 smd: 25(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-4X4-4-42P-1H
  custom 0.05x0.05 smd: 1(-2,1.4) 2(-2,1) 3(-2,0.6) 4(-2,0.2) 5(-2,-0.2) 6(-2,-0.6) 7(-2,-1) 8(-2,-1.4) 9(-1.4,-2) 10(-1,-2) 11(-0.6,-2) 12(-0.2,-2) 13(0.2,-2) 14(0.6,-2) 15(1,-2) 16(1.4,-2) 17(2,-1.4) 18(2,-1) 19(2,-0.6) 20(2,-0.2) 21(2,0.2) 22(2,0.6) 23(2,1) 24(2,1.4) 25(1.4,2) 26(1,2) 27(0.6,2) 28(0.2,2) 29(-0.2,2) 30(-0.6,2) 31(-1,2) 32(-1.4,2)
  rect 2.794x2.794 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1,1) 35(-1,0) 36(-1,-1) 37(0,-1) 38(1,-1) 39(1,0) 40(1,1) 41(0,1) 42(0,0)
QFN40-5X5-4-41P-92HD99
  rect 0.203x0.991 smd: 1(-1.8,-2.6) 2(-1.4,-2.6) 3(-1,-2.6) 4(-0.6,-2.6) 5(-0.2,-2.6) 6(0.2,-2.6) 7(0.6,-2.6) 8(1,-2.6) 9(1.4,-2.6) 10(1.8,-2.6) 21(1.8,2.6) 22(1.4,2.6) 23(1,2.6) 24(0.6,2.6) 25(0.2,2.6) 26(-0.2,2.6) 27(-0.6,2.6) 28(-1,2.6) 29(-1.4,2.6) 30(-1.8,2.6)
  rect 0.991x0.203 smd: 11(2.6,-1.8) 12(2.6,-1.4) 13(2.6,-1) 14(2.6,-0.6) 15(2.6,-0.2) 16(2.6,0.2) 17(2.6,0.6) 18(2.6,1) 19(2.6,1.4) 20(2.6,1.8) 31(-2.6,1.8) 32(-2.6,1.4) 33(-2.6,1) 34(-2.6,0.6) 35(-2.6,0.2) 36(-2.6,-0.2) 37(-2.6,-0.6) 38(-2.6,-1) 39(-2.6,-1.4) 40(-2.6,-1.8)
  rect 3.708x3.708 smd: 41(0,0)
QFN40-5X5-4-50P-0_75H
  custom 0.05x0.05 smd: 1(-2.475,1.8) 2(-2.475,1.4) 3(-2.475,1) 4(-2.475,0.6) 5(-2.475,0.2) 6(-2.475,-0.2) 7(-2.475,-0.6) 8(-2.475,-1) 9(-2.475,-1.4) 10(-2.475,-1.8) 11(-1.8,-2.475) 12(-1.4,-2.475) 13(-1,-2.475) 14(-0.6,-2.475) 15(-0.2,-2.475) 16(0.2,-2.475) 17(0.6,-2.475) 18(1,-2.475) 19(1.4,-2.475) 20(1.8,-2.475) 21(2.475,-1.8) 22(2.475,-1.4) 23(2.475,-1) 24(2.475,-0.6) 25(2.475,-0.2) 26(2.475,0.2) 27(2.475,0.6) 28(2.475,1) 29(2.475,1.4) 30(2.475,1.8) 31(1.8,2.475) 32(1.4,2.475) 33(1,2.475) 34(0.6,2.475) 35(0.2,2.475) 36(-0.2,2.475) 37(-0.6,2.475) 38(-1,2.475) 39(-1.4,2.475) 40(-1.8,2.475)
  rect 3.607x3.607 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-1,1) 43(-1,0) 44(-1,-1) 45(0,-1) 46(1,-1) 47(1,0) 48(1,1) 49(0,1) 50(0,0)
QFN48-7X7-5-49P-ALC113-GR
  rect 0.991x0.305 smd: 1(-3.6,2.75) 2(-3.6,2.25) 3(-3.6,1.75) 4(-3.6,1.25) 5(-3.6,0.75) 6(-3.6,0.25) 7(-3.6,-0.25) 8(-3.6,-0.75) 9(-3.6,-1.25) 10(-3.6,-1.75) 11(-3.6,-2.25) 12(-3.6,-2.75) 25(3.6,-2.75) 26(3.6,-2.25) 27(3.6,-1.75) 28(3.6,-1.25) 29(3.6,-0.75) 30(3.6,-0.25) 31(3.6,0.25) 32(3.6,0.75) 33(3.6,1.25) 34(3.6,1.75) 35(3.6,2.25) 36(3.6,2.75)
  rect 0.305x0.991 smd: 13(-2.75,-3.6) 14(-2.25,-3.6) 15(-1.75,-3.6) 16(-1.25,-3.6) 17(-0.75,-3.6) 18(-0.25,-3.6) 19(0.25,-3.6) 20(0.75,-3.6) 21(1.25,-3.6) 22(1.75,-3.6) 23(2.25,-3.6) 24(2.75,-3.6) 37(2.75,3.6) 38(2.25,3.6) 39(1.75,3.6) 40(1.25,3.6) 41(0.75,3.6) 42(0.25,3.6) 43(-0.25,3.6) 44(-0.75,3.6) 45(-1.25,3.6) 46(-1.75,3.6) 47(-2.25,3.6) 48(-2.75,3.6)
  rect 5.207x5.207 smd: 49(0,0)
QFN48-7X7-5-58P-PS8620
  custom 0.07x0.07 smd: 1(-3.475,2.75) 2(-3.475,2.25) 3(-3.475,1.75) 4(-3.475,1.25) 5(-3.475,0.75) 6(-3.475,0.25) 7(-3.475,-0.25) 8(-3.475,-0.75) 9(-3.475,-1.25) 10(-3.475,-1.75) 11(-3.475,-2.25) 12(-3.475,-2.75) 13(-2.75,-3.475) 14(-2.25,-3.475) 15(-1.75,-3.475) 16(-1.25,-3.475) 17(-0.75,-3.475) 18(-0.25,-3.475) 19(0.25,-3.475) 20(0.75,-3.475) 21(1.25,-3.475) 22(1.75,-3.475) 23(2.25,-3.475) 24(2.75,-3.475) 25(3.475,-2.75) 26(3.475,-2.25) 27(3.475,-1.75) 28(3.475,-1.25) 29(3.475,-0.75) 30(3.475,-0.25) 31(3.475,0.25) 32(3.475,0.75) 33(3.475,1.25) 34(3.475,1.75) 35(3.475,2.25) 36(3.475,2.75) 37(2.75,3.475) 38(2.25,3.475) 39(1.75,3.475) 40(1.25,3.475) 41(0.75,3.475) 42(0.25,3.475) 43(-0.25,3.475) 44(-0.75,3.475) 45(-1.25,3.475) 46(-1.75,3.475) 47(-2.25,3.475) 48(-2.75,3.475)
  rect 3.708x3.708 smd: 49(0,0)
  round 0.61 hole 0.305: 50(-1,1) 51(-1,0) 52(-1,-1) 53(0,-1) 54(1,-1) 55(1,0) 56(1,1) 57(0,1) 58(0,0)
RC0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
RC0603
  rect 0.813x0.711 smd: 1(0.737,0) 2(-0.737,0)
RC0805
  rect 0.94x1.346 smd: 1(0.895,0) 2(-0.895,0)
RC1206
  rect 1.6x1.6 smd: 1(1.702,0) 2(-1.702,0)
RC3216-4P
  custom 0.235x0.235 smd: 1(0,1.168) 2(0,-1.168)
  rect 1.092x0.559 smd: 1P(0,0.634) 2P(0,-0.634)
RJ45-JM361C-HP34AA03-9H-8P
  round 1.295 hole 0.889: 1(3.57,10.1) 2(2.55,11.2) 3(1.53,10.1) 4(0.51,11.2) 5(-0.51,10.1) 6(-1.53,11.2) 7(-2.55,10.1) 8(-3.57,11.2)
  oval 1.092x2.108 hole 0.61x1.6: 9(8.4,0) 10(8.4,7.8) 11(-8.4,0) 12(-8.4,7.8)
SATA-C166G1-12208-L-22P-R
  round 1.092 hole 1.092 unplated: (-17.7,0) (17.7,0)
  round 1.067 hole 0.711: 1(15.88,0) 2(14.61,0) 3(13.34,0) 4(12.07,0) 5(10.8,0) 6(9.53,0) 7(8.26,0) 8(1.91,0) 9(0.64,0) 10(-0.63,0) 11(-1.9,0) 12(-3.17,0) 13(-4.44,0) 14(-5.71,0) 15(-6.98,0) 16(-8.25,0) 17(-9.52,0) 18(-10.79,0) 19(-12.06,0) 20(-13.33,0) 21(-14.6,0) 22(-15.87,0)
  round 3.327 hole 2.311: 23(20,0.86) 24(-20,0.86)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SC74-2_8-95-6P
  rect 1.346x0.381 smd: 1(-1.325,-0.95) 2(-1.325,0) 3(-1.325,0.95) 4(1.325,0.95) 5(1.325,0) 6(1.325,-0.95)
SDCARD-CS1M-098-H-N-11P
  rect 1.397x1.295 smd: 1(-9.42,26.7) 2(-6.92,26.7) 3(-4.42,26.7) 4(-2.54,26.7) 5(-0.68,26.7) 6(1.16,26.7) 7(3.08,26.7) 8(5.58,26.7) 9(8,26.7) 10(9.75,26.7)
  rect 1.803x1.295 smd: 11(11.81,26.7)
  rect 1.575x2.489 hole 0.61x1.905: 12(14.325,19.65) 13(-16.925,19.65) 14(14.325,0) 15(-16.925,0)
SHORT0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
SHORT0402
  rect 0.648x0.5 smd: 1(-0.39,0) 2(0.39,0)
SHORT0603
  rect 1.168x0.711 smd: 1(0.737,0) 2(-0.737,0)
SHORT0805
  rect 1.397x1.346 smd: 1(0.895,0) 2(-0.895,0)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SHORT-1A
  rect 1.295x0.991 smd: 1(-0.6,0) 2(0.6,0)
SO-8FL-5P
  rect 0.991x0.762 smd: 1(3.73,-1.905) 2(3.73,-0.635) 3(3.73,0.635) 4(3.73,1.905)
  custom 1.132x1.132 smd: 5(0,0)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SOLDERJUMPER-2
  custom 0.381x0.381 smd: 1(-1.016,0) 2(1.016,0)
SON8-2X2-5-9P
  rect 0.279x0.508 smd: 1(-0.75,-0.95) 2(-0.25,-0.95) 3(0.25,-0.95) 4(0.75,-0.95) 5(0.75,0.95) 6(0.25,0.95) 7(-0.25,0.95) 8(-0.75,0.95)
  rect 1.6x0.889 smd: 9(0,0)
SON8-4_5X3_5-5-9P-SMT
  custom 0.05x0.05 smd: 1(-1.6,-1.6) 2(-1.2,-1.6) 3(-0.8,-1.6) 6(-0.8,1.6) 7(-1.2,1.6) 8(-1.6,1.6)
  custom 0.188x0.188 smd: 4(0.6,-1.6) 5(0.6,1.6)
  rect 4.039x2.21 smd: 9(0,0)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-6-4_2-95-6P
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
SOT23_123-2_37-1_9-1_11H
  rect 0.889x0.787 smd: 1(1,-0.95) 2(1,0.95) 3(-1,0)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SOT-363
  rect 1.219x0.254 smd: 1(1.038,-0.65) 2(1.038,0) 3(1.038,0.65) 4(-1.038,0.65) 5(-1.038,0) 6(-1.038,-0.65)
SSOP5-P-A-TOSHIBA-B
  rect 1.067x0.305 smd: 1(0.85,-0.65) 2(0.85,0) 3(0.85,0.65) 4(-0.85,0.65) 5(-0.85,-0.65)
SSOT6-2_8-95
  rect 0.991x0.711 smd: 1(1.3,-0.95) 2(1.3,0) 3(1.3,0.95) 4(-1.3,0.95) 5(-1.3,0) 6(-1.3,-0.95)
TDFN8-3X3-65-9P-0_85H
  rect 0.381x0.991 smd: 1(-0.975,-1.6) 2(-0.325,-1.6) 3(0.325,-1.6) 4(0.975,-1.6) 5(0.975,1.6) 6(0.325,1.6) 7(-0.325,1.6) 8(-0.975,1.6)
  rect 2.159x1.575 smd: 9(0,0)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TQFN20-3X3-4-21P
  rect 0.711x0.203 smd: 1(-1.5,0.8) 2(-1.5,0.4) 3(-1.5,0) 4(-1.5,-0.4) 5(-1.5,-0.8) 11(1.5,-0.8) 12(1.5,-0.4) 13(1.5,0) 14(1.5,0.4) 15(1.5,0.8)
  rect 0.203x0.711 smd: 6(-0.8,-1.5) 7(-0.4,-1.5) 8(0,-1.5) 9(0.4,-1.5) 10(0.8,-1.5) 16(0.8,1.5) 17(0.4,1.5) 18(0,1.5) 19(-0.4,1.5) 20(-0.8,1.5)
  rect 1.499x1.499 smd: 21(0,0)
TRF-9_4-1_27-24P
  rect 0.762x1.219 smd: 1(-6.985,-4.35) 2(-5.715,-4.35) 3(-4.445,-4.35) 4(-3.175,-4.35) 5(-1.905,-4.35) 6(-0.635,-4.35) 7(0.635,-4.35) 8(1.905,-4.35) 9(3.175,-4.35) 10(4.445,-4.35) 11(5.715,-4.35) 12(6.985,-4.35) 13(6.985,4.35) 14(5.715,4.35) 15(4.445,4.35) 16(3.175,4.35) 17(1.905,4.35) 18(0.635,4.35) 19(-0.635,4.35) 20(-1.905,4.35) 21(-3.175,4.35) 22(-4.445,4.35) 23(-5.715,4.35) 24(-6.985,4.35)
TSOP6-2_8-95
  rect 0.787x0.635 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,0) 6(-1.2,-0.95)
TSSOP8-4_9-65
  rect 0.432x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
UDFN10-2_5X1-5
  rect 0.254x0.508 smd: 1(-1,-0.4) 2(-0.5,-0.4) 4(0.5,-0.4) 5(1,-0.4) 6(1,0.4) 7(0.5,0.4) 9(-0.5,0.4) 10(-1,0.4)
  rect 0.457x0.508 smd: 3(0,-0.4) 8(0,0.4)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
USB-YBA-USB-032-P01-9P-RUH-SMT
  round 1.194 hole 0.787: 1(3.5,10.4) 2(1,10.4) 3(-1,10.4) 4(-3.5,10.4) 5(-4,8.9) 6(-2,8.9) 7(0,8.9) 8(2,8.9) 9(4,8.9)
  oval 1.778x2.718 hole 0.762x1.727: 10(7.75,10.4) 11(-7.75,10.4) 12(-7.75,0) 13(7.75,0)
USB-YUSB0012-P001A-10P
  round 1.194 hole 0.787: 1(3.5,9.23) 2(1,9.23) 3(-1,9.23) 5(-4.5,10.53) 6(-2.25,10.53) 7(0,10.53) 8(2.25,10.53) 9(4.5,10.53)
  round 1.041 hole 0.787: 4(-3.5,9.23)
  round 0.965 hole 0.762: 10(-4.7,9.26)
  oval 1.626x2.718 hole 0.61x1.702: 11(7.9,0) 12(-7.9,0) 13(-6.4,10.4) 14(6.4,10.4)
WQFN12-2X2-4-13P-SMT
  rect 0.61x0.203 smd: 1(-1.01,0.4) 2(-1.01,0) 3(-1.01,-0.4) 7(1.01,-0.4) 8(1.01,0) 9(1.01,0.4)
  rect 0.203x0.61 smd: 4(-0.4,-1.01) 5(0,-1.01) 6(0.4,-1.01) 10(0.4,1.01) 11(0,1.01) 12(-0.4,1.01)
  rect 0.889x0.889 smd: 13(0,0)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTL-3_2X2_5-2_2X1_7-4P
  rect 1.397x1.194 smd: 1(1.1,0.85) 2(-1.1,0.85) 3(-1.1,-0.85) 4(1.1,-0.85)

## Nets
1.5V_RUN_PWRGD: PU7.4 R189.2
1.05VGFX_OND: PC15.1 PQ27.3 PQ30.4 PR151.2
1.5VGFX_OND: PC18.1 PQ7.4 PQ25.3 PR141.2
1.5VGFX_OND#: PQ25.2 PQ33.2 PR49.2 PR50.1
3.3V_ALW_ON: Q32.3 R162.1 R282.1
3V3AUX: C258.1 C268.1 R177.1 U9.27
3V_FB2: PR69.1 PR76.1 PU4.5
3V_LGATE2: PQ44.4 PU4.12
3V_PHASE2: PC69.1 PL9.1 PQ44.5 PQ44.6 PQ44.7 PQ44.8 PQ48.1 PQ48.2 PQ48.3 PR198.2 PU4.11
3V_UGATE2: PQ48.4 PU4.10
3VGFX_OND: PC4.2 PQ3.3 PQ29.3 PR146.1
5V_BST1: PR92.2 PU4.22
5V_FB1: PR74.1 PR75.1 PU4.2
5V_LGATE1: PQ45.4 PU4.19
5V_PHASE1: PC65.2 PL10.2 PQ45.5 PQ45.6 PQ45.7 PQ45.8 PQ49.1 PQ49.2 PQ49.3 PR199.2 PU4.20
5V_UGATE1: PQ49.4 PU4.21
+1.1V_DSP: C219.1 C246.1 C264.2 C266.2 C308.1 PC252.1 PC253.1 PR432.1 PU11.5 R524.1 U7.9 U7.15 U7.16
+1.05V_GFX: C2.1 C3.1 C6.2 C8.1 C15.2 C16.1 C17.1 C36.1 C38.2 C42.1 C44.1 C406.2 C409.2 C412.2 L1.2 L3.2 L9.1 L10.2 PC124.1 PC128.1 PQ30.1 PQ30.2 PQ30.3 PR9.1 R386.2 U13.AA10 U13.AA12 U13.AA13 U13.AA16 U13.AA18 U13.AA19 U13.AA20 U13.AA21 U13.AA22 U13.AB22 U13.AB23 U13.AC23 U13.AC24 U13.AD24 U13.AD25 U13.AE25 U13.AE26 U13.AE27 U13.AF26 U13.AF27
+1.05V_RUN: C53.2 C64.1 C67.1 C88.2 C105.2 C118.2 C149.1 C151.1 C152.1 C156.2 L2.1 L11.1 L20.1 PC13.2 PQ4.1 PQ4.2 PQ4.3 PR11.2 R54.1 R283.2 R524.2 U14.AE8 U14.AE9 U14.AF9 U14.AF22 U14.AG8 U14.AG13 U14.AG14 U14.AG16 U14.AG17 U14.H11 U14.H15 U14.J11 U14.J17 U14.N8 U14.P9 U14.R21 U14.T21
+1.5V_RUN: C435.1 C436.1 C437.1 C438.1 C439.1 C443.1 PC86.1 PC87.1 PC88.1 PC89.1 PC250.1 PC251.1 PL2.1 PR127.1 PU11.6 R95.2 U2.19 U2.20 U2.31 U2.40 U14.J15
+1.05V_SUS: C66.2 C92.1 C130.1 C154.1 L8.1 PC12.1 PC83.1 PC100.1 PC127.2 PL1.2 PQ1.5 PQ4.5 PQ30.5 PR8.1 R63.1 R67.1 R340.1 R346.2 U14.AD8 U14.AD10 U14.AH13 U14.J13
+1.35V_GFX: C5.2 C9.1 C21.2 C26.1 C29.1 C33.2 C47.2 C56.1 C57.2 C81.2 C98.2 C109.2 C124.2 C133.2 C134.2 C140.1 C141.2 C157.2 C159.2 C160.1 C161.1 C162.2 C164.1 C173.2 C176.2 C177.2 C188.1 C407.1 C414.1 C427.1 C428.1 C429.2 C430.2 C431.2 C432.2 C433.1 C434.2 C447.1 C449.1 C459.1 D2.2 PC19.1 PC20.1 PQ7.1 PQ7.2 PQ7.3 PR175.1 R47.2 R64.1 R68.1 R80.1 R89.2 R301.2 R360.2 R398.2 U13.B26 U13.C25 U13.E23 U13.E26 U13.F14 U13.F21 U13.G13 U13.G14 U13.G15 U13.G16 U13.G18 U13.G19 U13.G20 U13.G21 U13.H24 U13.H26 U13.J21 U13.K21 U13.L22 U13.L24 U13.L26 U13.M21 U13.N21 U13.R21 U13.T21 U13.V21 U13.W21 VRAM1.A1 VRAM1.A8 VRAM1.B2 VRAM1.C1 VRAM1.C9 VRAM1.D2 VRAM1.D9 VRAM1.E9 VRAM1.F1 VRAM1.G7 VRAM1.H2 VRAM1.H9 VRAM1.K2 VRAM1.K8 VRAM1.N1 VRAM1.N9 VRAM1.R1 VRAM1.R9 VRAM2.A1 VRAM2.A8 VRAM2.B2 VRAM2.C1 VRAM2.C9 VRAM2.D2 VRAM2.D9 VRAM2.E9 VRAM2.F1 VRAM2.G7 VRAM2.H2 VRAM2.H9 VRAM2.K2 VRAM2.K8 VRAM2.N1 VRAM2.N9 VRAM2.R1 VRAM2.R9 VRAM3.A1 VRAM3.A8 VRAM3.B2 VRAM3.C1 VRAM3.C9 VRAM3.D2 VRAM3.D9 VRAM3.E9 VRAM3.F1 VRAM3.G7 VRAM3.H2 VRAM3.H9 VRAM3.K2 VRAM3.K8 VRAM3.N1 VRAM3.N9 VRAM3.R1 VRAM3.R9 VRAM4.A1 VRAM4.A8 VRAM4.B2 VRAM4.C1 VRAM4.C9 VRAM4.D2 VRAM4.D9 VRAM4.E9 VRAM4.F1 VRAM4.G7 VRAM4.H2 VRAM4.H9 VRAM4.K2 VRAM4.K8 VRAM4.N1 VRAM4.N9 VRAM4.R1 VRAM4.R9
+2VREF: PC52.2 PU4.3
+3.3V_ALW: C23.1 C211.2 C220.2 C484.2 C513.1 ESD4.5 ESD5.5 ESD6.5 HE1.2 PC11.1 PC38.1 PC172.1 PC176.2 PL9.2 PQ3.1 PQ3.2 PQ3.5 PQ3.6 PQ9.1 PQ9.2 PQ9.5 PQ9.6 PQ10.1 PQ10.2 PQ10.5 PQ10.6 PR24.1 PR67.2 PR89.1 PR150.1 PR194.1 PR204.2 PR426.1 PU2.1 PU2.2 PU4.7 Q29.1 Q29.2 Q29.5 Q29.6 R1.2 R2.2 R175.2 R220.1 R221.2 R224.2 R254.2 R279.2 R442.2 R447.2 R468.2 R471.1 R473.1 RP10.2 RP10.4 RP11.2 RP11.4 RT1.1 U24.8
+3.3V_ALW_AVCC: C491.2 L23.1 U23.74
+3.3V_AUDIO: C224.1 C225.1 C234.1 C238.1 C306.1 C307.1 C327.2 C330.1 PR73.2 Q20.2 Q20.5 R171.1 R173.1 R277.1 U7.17 U10.9
+3.3V_AUX: C265.1 C333.1 C395.1 C399.1 C537.2 C538.2 CN14.2 CN14.4 CN14.72 CN14.74 Q21.2 Q29.4 R197.2 R225.2 R236.2 R240.2 R500.1
+3.3V_EC: C250.1 C256.1 C316.2 C318.2 C319.2 L23.2 R224.1 U23.26 U23.50 U23.92 U23.114 U23.121 U23.127
+3.3V_EN2: PQ12.2 R157.2 R160.2 R162.2
+3.3V_RTC_LDO: PC60.1 PR78.2 PR90.1 PR91.2 PU4.8 R280.2 R282.2 RTCD1.2
+3.3V_RUN: C60.2 C87.1 C90.2 C91.2 C115.2 C193.2 C217.1 C218.1 C442.1 C444.1 C486.1 C490.1 C534.1 C535.1 CN8.1 CN11.3 CN11.4 HDMIF3.2 JDIM1.199 PC46.2 PQ10.4 PR36.1 PR58.2 PR73.1 PR153.2 PR154.1 PR181.1 PU9.21 Q23.2 Q34.2 Q34.5 Q42.2 R3.2 R7.2 R8.2 R9.1 R25.2 R28.2 R32.2 R34.2 R36.2 R38.2 R39.2 R40.2 R42.2 R43.2 R45.2 R48.2 R51.2 R53.2 R79.1 R87.1 R91.1 R165.2 R203.2 R205.2 R238.1 R240.1 R259.2 R269.2 R274.2 R281.1 R297.2 R298.2 R305.2 R307.2 R308.2 R310.2 R314.1 R315.1 R318.2 R322.2 R323.2 R331.2 R357.1 R370.1 R380.1 R384.2 R399.2 R414.2 R427.2 R435.2 R444.2 R453.1 R476.2 R505.1 R507.2 R508.2 R509.2 R513.1 R518.2 RN1.2 RN1.4 RN1.6 RN1.8 RP1.1 RP1.3 RP2.2 RP2.4 RP3.1 RP3.3 RP4.1 RP4.3 RP5.1 RP5.3 RP6.1 RP6.3 RP12.2 RP12.4 RP14.1 RP14.3 RP15.1 RP15.3 RP16.1 RP16.3 RP17.2 RP17.4 RP22.2 RP22.4 U1.5 U2.11 U2.37 U14.K14 U14.K16 U14.V8 U14.W9 U15.5 U22.4 U22.5 U23.11 U25.1 U25.6 U25.12 U25.25 U25.32 U25.36
+3.3V_RUN_F: CN1.19 CN1.20 HDMIF3.1
+3.3V_SUS: C108.1 C128.1 C153.1 C168.1 C487.1 C525.1 PC36.2 PQ9.4 PR136.2 PR140.1 Q37.2 Q37.5 R56.1 R65.2 R66.2 R69.2 R74.2 R77.2 R78.2 R81.2 R84.2 R88.2 R102.2 R121.2 R122.2 R123.2 R124.2 R125.2 R131.2 R146.1 R332.2 R336.2 R337.2 R338.2 R344.2 R345.2 R350.2 R352.2 R354.2 R358.2 R365.2 R396.1 R451.1 R461.1 R462.1 RP19.2 RP19.4 RP20.2 RP20.4 RP21.2 RP21.4 RP23.2 RP23.4 U14.AA9 U14.AC9 U14.AE20 U14.AE21 U14.AH10 U14.AH11 U14.AH14 U21.8
+3.3V_TP_PWR: C516.1 C517.1 CN15.1 R476.1
+3V_GFX: C39.1 C40.2 C46.1 C54.1 C125.1 C135.1 C136.1 C163.1 C165.1 D2.1 D3.1 PC9.1 PC10.1 PQ3.4 PR179.1 Q14.2 Q14.5 R35.2 R94.2 R96.2 R97.2 R98.2 R100.2 R104.2 R126.2 R127.2 R137.2 R343.2 R349.2 R356.2 R362.2 R371.2 R372.2 R373.1 R374.1 R375.2 R376.2 R412.2 R413.2 U13.AA8 U13.AA9 U13.AB8 U13.G8 U13.G9 U13.G10 U13.G12
+3VLANVCC: C208.2 C209.2 C236.2 C237.1 C249.1 C251.1 PC167.1 Q41.2 R174.1 R431.1 R439.1 R445.2 R453.2 U6.11 U6.23 U6.32
+5V_ALW: C465.1 C467.1 C468.1 C471.1 C474.1 C475.2 ESD1.5 ESD2.5 ESD3.5 PC43.1 PC63.1 PC66.2 PC103.1 PC106.1 PC110.1 PC175.1 PL10.1 PQ19.1 PQ19.2 PQ19.5 PQ19.6 PR1.1 PR88.1 PR196.1 PU2.4 PU4.24 PU5.15 PU7.8 PU7.9 PU7.10 R151.1 R155.1 R419.1 R420.1 R482.2 U16.2 U16.3 U17.2 U17.3 U18.1
+5V_AUDIO: C242.1 C244.2 C245.2 C260.1 L12.1 L13.1 L24.2 R449.1
+5V_AVDD: C492.1 C493.1 C500.2 C501.1 C506.1 C510.1 L24.1 U10.27 U10.38
+5V_FAN: C476.2 C477.1 FAN1.1 R425.2 R438.2
+5V_FAN2: C472.1 C473.2 FAN2.1 R149.2 R422.2
+5V_HDMIF1: CN3.18 D9.2 D10.2 HDMIF1.2
+5V_HDMIF1_D: D10.1 RP18.1
+5V_HDMIF1_D35: D9.1 RP18.3
+5V_RUN: C45.1 C508.1 C514.1 C518.1 C522.1 CN17.14 CN17.15 CN17.16 HDMIF1.1 HDMIF2.2 PC31.2 PC67.2 PC85.1 PC115.1 PC249.1 PQ19.4 PQ24.2 PQ26.2 PR34.2 PR132.2 PU1.21 PU11.1 PU11.3 R149.1 R253.1 R438.1 R449.2
+5V_RUN_F: CN1.17 HDMIF2.1
+5VPCU: PC72.1 PR57.1 PU4.4 PU4.17
+12V_ALW: PC70.1 PD8.1 PR141.1 PR146.2 PR151.1 PU6.13 Q4.1 R11.2 R244.2 R246.1
+V1.05A_AOSCSUS: C117.2 C120.1 C121.1 C122.1 L8.2 U14.AB8
+V1.05DX_MODPHY: C11.1 C18.2 C84.2 C95.2 L19.1 L21.1 PQ1.1 PQ1.2 PQ1.3 PR12.2 R283.1 U14.K9 U14.L10 U14.M9
+V1.05S_APLLOPI: C126.1 C127.1 C129.2 L11.2 U14.AA21 U14.W21
+V1.05S_ASATA3PLL: C415.2 C419.1 C426.1 L19.2 R288.2 R294.2 U14.B11
+V1.05S_AUSB3PLL: C417.1 C421.2 C424.1 L21.2 R19.1 R20.1 U14.B18
+V1.05S_AXCK_DCB: C12.2 C19.1 C55.1 L2.2 U14.J18 U14.K19
+V1.05S_AXCK_LCPLL: C411.2 C418.1 C425.1 L20.2 R21.2 U14.A20
+V1.05S_VCCST: PR2.1 R12.2 R14.1 R15.1 R33.2 R37.2 R54.2 R311.2 R313.1 R320.1 U14.AC22 U14.AE22 U14.AE23
+V3.3_THERMAL: C194.1 Q17.2 Q17.5 R115.1 R139.1 R427.1 RP9.2 RP9.4 U3.1
+V3.3_THERMAL2: C199.1 Q15.2 Q15.5 R137.1 RP8.2 RP8.4 U4.1
+V3.3DX_CR: C272.1 C285.1 Q30.2 R177.2 R188.1 R199.1 R243.2 R281.2 U9.11
+V3.3S_1.8S_LPSS_SDIO: C102.1 R299.2 R315.2 U14.T9 U14.U8
+VCCIN: C49.1 C50.1 C51.1 C52.1 C62.1 C63.1 C69.1 C70.1 C71.1 C72.1 C73.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C82.1 C83.1 C94.1 C97.1 C106.1 C107.1 C119.1 C123.1 C132.1 C148.1 C158.1 PC5.1 PC116.1 PC117.1 PC120.1 PC121.1 PC122.1 PC123.1 PC129.1 PC130.1 PC131.1 PC132.1 PC133.1 PC134.1 PC135.1 PL3.2 PL4.2 R304.2 U14.AB57 U14.AD57 U14.AG57 U14.C24 U14.C28 U14.C32 U14.C36 U14.C40 U14.C44 U14.C48 U14.C52 U14.C56 U14.E23 U14.E25 U14.E27 U14.E29 U14.E31 U14.E33 U14.E35 U14.E37 U14.E39 U14.E41 U14.E43 U14.E45 U14.E47 U14.E49 U14.E51 U14.E53 U14.E55 U14.E57 U14.F24 U14.F28 U14.F32 U14.F36 U14.F40 U14.F44 U14.F48 U14.F52 U14.F56 U14.F59 U14.G23 U14.G25 U14.G27 U14.G29 U14.G31 U14.G33 U14.G35 U14.G37 U14.G39 U14.G41 U14.G43 U14.G45 U14.G47 U14.G49 U14.G51 U14.G53 U14.G55 U14.G57 U14.H23 U14.J23 U14.K23 U14.K57 U14.L22 U14.M23 U14.M57 U14.P57 U14.U57 U14.W57
+VCCIO_OUT: PR3.1 R316.1 R317.2 R321.1 U14.A59
+VCCIOA_OUT: R22.2 U14.E20
+VCCRTCEXT: C131.2 U14.AE7
+VIN: C521.1 EC1.1 EC7.2 EC8.1 EC9.1 EC10.1 EC11.1 EC12.1 EC23.1 EC24.1 PC1.1 PC2.1 PC3.1 PC7.1 PC92.1 PC93.1 PC94.1 PC96.1 PC97.1 PC99.1 PC101.1 PC112.1 PC141.1 PC149.1 PC152.1 PC154.1 PC155.1 PC157.2 PC159.1 PC160.1 PC161.2 PC162.1 PC164.1 PC165.1 PC168.1 PC169.1 PC170.1 PC178.2 PC180.2 PC183.1 PC184.1 PC185.1 PC186.2 PC187.1 PC188.1 PC189.1 PC190.1 PC192.1 PC193.1 PC194.1 PC195.1 PC196.2 PQ17.4 PQ20.1 PQ20.2 PQ20.3 PQ23.5 PQ23.6 PQ23.7 PQ23.8 PQ24.5 PQ26.5 PQ38.5 PQ40.5 PQ43.5 PQ43.6 PQ43.7 PQ43.8 PQ46.5 PQ46.6 PQ46.7 PQ46.8 PQ48.5 PQ48.6 PQ48.7 PQ48.8 PQ49.5 PQ49.6 PQ49.7 PQ49.8 PR80.1 PR100.1 PR106.1 PR113.2 PR117.2 PR168.1 PR183.2 PR188.1 Q28.1 R479.1
AGND: C259.1 C278.1 C284.2 C289.1 C332.2 C337.2 C338.1 C352.1 C353.1 C355.2 C488.1 C492.2 C493.2 C500.1 C501.2 C506.2 C510.2 C520.1 CN12.3 CN12.6 CN12.7 Q48.1 R266.2 R270.1 R273.2 R276.1 R455.1 U10.26 U10.33
AV12: C254.1 C262.1 C299.1 C315.1 U9.10 U9.14
DV33_18: C253.2 U9.18
GND: C1.1 C2.2 C3.2 C4.2 C5.1 C6.1 C8.2 C9.2 C11.2 C12.1 C13.1 C15.1 C16.2 C17.2 C18.1 C19.2 C21.1 C22.2 C23.2 C26.2 C29.2 C30.2 C31.1 C32.1 C33.1 C34.1 C35.1 C36.2 C37.2 C38.1 C39.2 C40.1 C41.1 C42.2 C43.1 C44.2 C45.2 C46.2 C47.1 C48.1 C49.2 C50.2 C51.2 C52.2 C53.1 C54.2 C55.2 C56.2 C57.1 C58.1 C59.1 C60.1 C61.1 C62.2 C63.2 C64.2 C65.1 C66.1 C67.2 C68.1 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.1 C81.1 C82.2 C83.2 C84.1 C85.1 C86.1 C87.2 C88.1 C89.1 C90.1 C91.1 C92.2 C93.1 C94.2 C95.1 C96.1 C97.2 C98.1 C99.1 C100.1 C101.1 C102.2 C103.1 C104.1 C105.1 C106.2 C107.2 C108.2 C109.1 C110.1 C111.1 C112.1 C113.1 C115.1 C116.1 C117.1 C118.1 C119.2 C120.2 C121.2 C122.2 C123.2 C124.1 C125.2 C126.2 C127.2 C128.2 C129.1 C130.2 C131.1 C132.2 C133.1 C134.1 C135.2 C136.2 C137.1 C138.2 C139.1 C140.2 C141.1 C142.1 C143.1 C144.1 C145.2 C146.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.1 C156.1 C157.1 C158.2 C159.1 C160.2 C161.2 C162.1 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.1 C170.2 C172.1 C173.1 C175.1 C176.1 C177.1 C186.1 C187.1 C188.2 C189.1 C190.2 C192.1 C193.1 C194.2 C195.1 C196.2 C197.2 C199.2 C201.2 C202.2 C203.2 C204.2 C207.1 C208.1 C209.1 C211.1 C212.2 C217.2 C218.2 C219.2 C220.1 C221.2 C222.1 C223.1 C224.2 C225.2 C226.1 C227.1 C228.2 C229.2 C230.1 C231.2 C232.2 C233.2 C234.2 C236.1 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.1 C245.1 C246.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.1 C254.2 C255.1 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.1 C264.1 C265.2 C266.1 C268.2 C269.2 C270.2 C272.2 C273.1 C276.2 C277.2 C278.2 C279.2 C285.2 C287.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C299.2 C300.1 C301.1 C302.1 C303.1 C304.1 C305.1 C306.2 C307.2 C308.2 C314.2 C315.2 C316.1 C317.1 C318.1 C319.1 C321.2 C322.2 C327.1 C330.2 C333.2 C335.1 C341.2 C342.2 C344.1 C349.2 C359.1 C360.2 C361.1 C369.2 C370.2 C371.2 C372.2 C373.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C384.2 C385.2 C386.2 C387.2 C388.2 C389.2 C390.2 C391.2 C392.2 C393.1 C395.2 C397.2 C398.2 C399.2 C401.2 C406.1 C407.2 C409.1 C411.1 C412.1 C414.2 C415.1 C417.2 C418.2 C419.2 C420.2 C421.1 C422.2 C423.2 C424.2 C425.2 C426.2 C427.2 C428.2 C429.1 C430.1 C431.1 C432.1 C433.2 C434.1 C435.2 C436.2 C437.2 C438.2 C439.2 C440.2 C441.2 C442.2 C443.2 C444.2 C445.1 C446.1 C447.2 C448.2 C449.2 C450.2 C451.2 C452.2 C453.2 C454.2 C455.2 C456.2 C457.1 C458.1 C459.2 C460.2 C461.2 C462.2 C463.1 C464.1 C465.2 C466.2 C467.2 C468.2 C469.1 C470.2 C471.2 C472.2 C473.1 C474.2 C475.1 C476.1 C477.2 C478.2 C479.2 C480.2 C481.1 C482.2 C483.2 C484.1 C486.2 C487.2 C488.2 C490.2 C494.2 C495.2 C496.2 C497.2 C498.1 C499.2 C502.2 C503.1 C504.1 C505.1 C507.1 C508.2 C509.2 C511.1 C512.2 C513.2 C514.2 C515.2 C516.2 C517.2 C518.2 C519.2 C520.2 C522.2 C523.2 C524.2 C532.2 C534.2 C535.2 C536.2 C537.1 C538.1 C539.1 C540.1 CN1.1 CN1.4 CN1.7 CN1.10 CN1.13 CN1.21 CN1.22 CN1.23 CN1.24 CN2.2 CN2.3 CN2.4 CN3.2 CN3.5 CN3.8 CN3.11 CN3.17 CN3.20 CN3.21 CN3.22 CN3.23 CN4.4 CN4.7 CN4.10 CN4.11 CN4.12 CN4.13 CN5.4 CN5.7 CN5.10 CN5.11 CN5.12 CN5.13 CN6.4 CN6.7 CN6.11 CN6.12 CN6.13 CN6.14 CN7.9 CN7.10 CN7.11 CN7.12 CN8.5 CN8.7 CN8.8 CN9.5 CN9.8 CN9.12 CN9.13 CN9.14 CN9.15 CN11.6 CN11.9 CN11.12 CN11.15 CN11.16 CN11.19 CN11.25 CN11.31 CN11.32 CN11.33 CN11.34 CN14.1 CN14.7 CN14.18 CN14.33 CN14.39 CN14.45 CN14.51 CN14.57 CN14.63 CN14.69 CN14.75 CN14.76 CN14.77 CN15.4 CN16.27 CN16.28 CN16.33 CN16.34 CN17.1 CN17.4 CN17.7 CN17.11 CN17.12 CN17.13 CN17.17 CN17.19 CN18.7 CN18.8 CN18.9 CN18.10 EC1.2 EC2.2 EC3.2 EC4.2 EC5.2 EC6.2 EC7.1 EC8.2 EC9.2 EC10.2 EC11.2 EC12.2 EC13.2 EC14.2 EC15.1 EC16.1 EC17.1 EC18.1 EC19.1 EC20.1 EC21.1 EC22.1 EC23.2 EC24.2 EC33.1 EC34.1 EC35.1 EC36.1 EC37.1 EC38.1 ESD1.2 ESD2.2 ESD3.2 ESD4.2 ESD5.2 ESD6.2 EU1.3 EU1.8 EU2.3 EU2.8 EU3.3 EU3.8 FAN1.3 FAN2.3 G1.2 G2.1 H3.1 H4.1 H5.1 H6.1 H7.1 H8.1 H8.2 H8.3 H8.4 H9.1 H10.1 H11.1 H12.1 H13.1 H14.1 H17.1 HE1.3 JDIM1.2 JDIM1.3 JDIM1.8 JDIM1.9 JDIM1.11 JDIM1.13 JDIM1.14 JDIM1.19 JDIM1.20 JDIM1.25 JDIM1.26 JDIM1.28 JDIM1.31 JDIM1.32 JDIM1.37 JDIM1.38 JDIM1.43 JDIM1.44 JDIM1.46 JDIM1.48 JDIM1.49 JDIM1.54 JDIM1.55 JDIM1.60 JDIM1.61 JDIM1.63 JDIM1.65 JDIM1.66 JDIM1.71 JDIM1.72 JDIM1.127 JDIM1.128 JDIM1.133 JDIM1.134 JDIM1.136 JDIM1.138 JDIM1.139 JDIM1.144 JDIM1.145 JDIM1.150 JDIM1.151 JDIM1.153 JDIM1.155 JDIM1.156 JDIM1.161 JDIM1.162 JDIM1.167 JDIM1.168 JDIM1.170 JDIM1.172 JDIM1.173 JDIM1.178 JDIM1.179 JDIM1.184 JDIM1.185 JDIM1.187 JDIM1.189 JDIM1.190 JDIM1.195 JDIM1.196 JDIM1.207 JDIM1.208 L25.2 PC1.2 PC2.2 PC3.2 PC4.1 PC5.2 PC6.2 PC7.2 PC8.2 PC9.2 PC10.2 PC11.2 PC12.2 PC13.1 PC14.2 PC15.2 PC17.2 PC18.2 PC19.2 PC20.2 PC21.1 PC22.1 PC23.2 PC24.2 PC25.2 PC31.1 PC36.1 PC37.2 PC38.2 PC39.2 PC40.2 PC41.2 PC42.2 PC43.2 PC46.1 PC47.2 PC48.2 PC50.1 PC51.2 PC52.1 PC53.2 PC57.2 PC58.1 PC59.2 PC60.2 PC62.1 PC63.2 PC64.2 PC66.1 PC67.1 PC68.2 PC70.2 PC71.2 PC72.2 PC73.1 PC74.1 PC75.2 PC76.2 PC77.2 PC78.2 PC79.1 PC81.1 PC82.2 PC83.2 PC84.1 PC85.2 PC86.2 PC87.2 PC88.2 PC91.2 PC92.2 PC93.2 PC94.2 PC96.2 PC97.2 PC99.2 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC110.2 PC112.2 PC115.2 PC116.2 PC117.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC127.1 PC128.2 PC129.2 PC130.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC139.2 PC140.2 PC141.2 PC142.2 PC143.1 PC144.2 PC149.2 PC150.1 PC152.2 PC153.1 PC154.2 PC155.2 PC157.1 PC158.1 PC159.2 PC160.2 PC161.1 PC162.2 PC164.2 PC165.2 PC167.2 PC168.2 PC169.2 PC170.2 PC171.1 PC172.2 PC173.2 PC174.2 PC175.2 PC176.1 PC178.1 PC179.2 PC180.1 PC181.2 PC182.1 PC183.2 PC184.2 PC185.2 PC186.1 PC187.2 PC188.2 PC189.2 PC190.2 PC191.2 PC192.2 PC193.2 PC194.2 PC195.2 PC196.1 PC197.2 PC198.2 PC199.1 PC200.2 PC241.2 PC249.2 PC250.2 PC251.2 PC252.2 PC253.2 PC254.2 PQ2.1 PQ5.1 PQ5.4 PQ6.1 PQ6.4 PQ8.1 PQ12.1 PQ13.1 PQ14.1 PQ15.1 PQ16.1 PQ16.4 PQ18.1 PQ21.1 PQ22.1 PQ24.3 PQ24.9 PQ25.1 PQ26.3 PQ26.9 PQ27.1 PQ28.1 PQ28.2 PQ28.3 PQ29.1 PQ31.6 PQ33.1 PQ34.1 PQ36.1 PQ36.2 PQ36.3 PQ37.1 PQ39.1 PQ39.2 PQ39.3 PQ41.1 PQ42.1 PQ42.2 PQ42.3 PQ44.1 PQ44.2 PQ44.3 PQ45.1 PQ45.2 PQ45.3 PQ47.1 PQ47.2 PQ47.3 PQ50.1 PQ50.4 PR25.1 PR33.2 PR38.1 PR45.2 PR59.2 PR65.2 PR68.2 PR74.2 PR76.2 PR79.2 PR81.2 PR85.1 PR87.2 PR95.2 PR101.2 PR102.2 PR107.2 PR108.1 PR109.1 PR112.2 PR120.2 PR124.2 PR130.2 PR133.2 PR148.2 PR149.1 PR158.2 PR174.2 PR177.1 PR191.2 PR425.2 PR427.2 PR434.1 PU1.22 PU2.5 PU2.9 PU3.14 PU3.21 PU3.22 PU3.23 PU3.24 PU3.25 PU4.14 PU4.15 PU4.25 PU5.1 PU5.3 PU5.4 PU5.17 PU5.18 PU5.25 PU6.21 PU7.11 PU8.12 PU8.13 PU9.29 PU9.33 PU9.34 PU9.35 PU9.36 PU9.37 PU9.38 PU9.39 PU9.40 PU9.41 PU9.42 PU11.2 Q1.1 Q3.1 Q3.4 Q5.1 Q6.1 Q8.1 Q9.1 Q16.1 Q19.1 Q19.4 Q24.1 Q24.4 Q26.1 Q27.1 Q32.1 Q32.4 Q33.1 Q36.1 Q38.1 Q40.1 Q40.4 Q43.1 Q44.1 Q44.4 Q45.1 Q46.4 Q47.1 R6.1 R10.2 R13.1 R17.2 R24.1 R27.2 R31.1 R41.1 R46.2 R49.1 R57.2 R58.2 R60.2 R61.2 R70.1 R72.1 R73.1 R76.2 R83.2 R85.1 R86.1 R93.1 R99.2 R101.1 R105.2 R106.2 R107.2 R108.2 R110.1 R111.1 R112.1 R114.1 R138.1 R141.1 R150.1 R153.1 R161.1 R164.2 R201.1 R207.1 R219.1 R231.1 R250.1 R255.1 R276.2 R284.2 R285.1 R287.1 R289.2 R290.2 R295.2 R296.1 R300.1 R302.1 R303.2 R306.2 R319.2 R325.1 R326.2 R327.2 R328.2 R330.2 R334.2 R335.2 R339.2 R341.2 R342.1 R348.1 R351.1 R353.2 R355.1 R359.1 R361.1 R363.2 R364.1 R366.1 R367.2 R368.1 R369.1 R377.1 R381.2 R382.2 R383.2 R387.1 R388.2 R389.2 R392.2 R397.2 R400.1 R401.1 R402.2 R404.2 R421.1 R429.1 R430.1 R436.2 R441.2 R443.2 R448.2 R454.2 R455.2 R464.2 R467.2 R469.2 R483.2 R502.1 R503.2 R504.2 R506.1 R510.2 R511.2 R512.2 R519.2 R528.2 RP7.2 RP7.4 RP13.2 RP13.4 RTCBT1.2 SJ1.1 U1.3 U2.8 U2.35 U2.41 U2.42 U2.43 U2.44 U2.45 U2.46 U2.47 U2.48 U2.49 U2.50 U3.5 U4.5 U5.3 U6.33 U7.8 U7.12 U7.20 U7.22 U7.26 U7.30 U7.40 U7.41 U9.33 U10.42 U10.49 U13.A2 U13.A26 U13.AA7 U13.AB7 U13.AB11 U13.AB14 U13.AB17 U13.AB20 U13.AB24 U13.AC2 U13.AC5 U13.AC8 U13.AC22 U13.AC26 U13.AD12 U13.AD13 U13.AD15 U13.AD16 U13.AD18 U13.AD19 U13.AD21 U13.AD22 U13.AE11 U13.AE14 U13.AE17 U13.AE20 U13.AF1 U13.AF5 U13.AF8 U13.AF11 U13.AF14 U13.AF17 U13.AF20 U13.AF23 U13.AG2 U13.AG26 U13.B1 U13.B5 U13.B8 U13.B11 U13.B14 U13.B17 U13.B20 U13.B23 U13.B27 U13.E2 U13.E5 U13.E8 U13.E11 U13.E14 U13.E17 U13.E20 U13.E22 U13.E25 U13.H2 U13.H5 U13.H23 U13.H25 U13.K11 U13.K13 U13.K15 U13.K17 U13.L2 U13.L5 U13.L10 U13.L12 U13.L14 U13.L16 U13.L18 U13.L23 U13.L25 U13.M11 U13.M13 U13.M15 U13.M17 U13.N10 U13.N12 U13.N14 U13.N16 U13.N18 U13.P2 U13.P5 U13.P11 U13.P13 U13.P15 U13.P17 U13.P23 U13.P26 U13.R10 U13.R12 U13.R14 U13.R16 U13.R18 U13.T11 U13.T13 U13.T15 U13.T17 U13.U2 U13.U5 U13.U10 U13.U12 U13.U14 U13.U16 U13.U18 U13.U23 U13.U26 U13.V11 U13.V13 U13.V15 U13.V17 U13.Y2 U13.Y5 U13.Y23 U13.Y26 U14.A11 U14.A14 U14.A18 U14.A24 U14.A28 U14.A32 U14.A36 U14.A40 U14.A44 U14.A48 U14.A52 U14.A56 U14.AA1 U14.AA58 U14.AB7 U14.AB10 U14.AB20 U14.AB22 U14.AC61 U14.AD3 U14.AD21 U14.AD63 U14.AE5 U14.AE10 U14.AE58 U14.AF11 U14.AF12 U14.AF14 U14.AF15 U14.AF17 U14.AF18 U14.AG1 U14.AG11 U14.AG21 U14.AG23 U14.AG60 U14.AG61 U14.AG62 U14.AG63 U14.AH16 U14.AH17 U14.AH19 U14.AH20 U14.AH22 U14.AH24 U14.AH28 U14.AH30 U14.AH32 U14.AH34 U14.AH36 U14.AH38 U14.AH40 U14.AH42 U14.AH44 U14.AH46 U14.AH49 U14.AH51 U14.AH53 U14.AH55 U14.AH57 U14.AJ13 U14.AJ14 U14.AJ23 U14.AJ25 U14.AJ27 U14.AJ29 U14.AJ35 U14.AJ39 U14.AJ41 U14.AJ43 U14.AJ45 U14.AJ47 U14.AJ50 U14.AJ52 U14.AJ54 U14.AJ56 U14.AJ58 U14.AJ60 U14.AJ63 U14.AK3 U14.AK23 U14.AK52 U14.AL10 U14.AL13 U14.AL17 U14.AL20 U14.AL22 U14.AL23 U14.AL26 U14.AL29 U14.AL31 U14.AL33 U14.AL36 U14.AL39 U14.AL40 U14.AL45 U14.AL46 U14.AL51 U14.AL52 U14.AL54 U14.AL57 U14.AL60 U14.AL61 U14.AM1 U14.AM17 U14.AM23 U14.AM31 U14.AM52 U14.AN7 U14.AN17 U14.AN23 U14.AN31 U14.AN32 U14.AN35 U14.AN36 U14.AN39 U14.AN40 U14.AN42 U14.AN43 U14.AN45 U14.AN46 U14.AN48 U14.AN49 U14.AN51 U14.AN52 U14.AN60 U14.AN63 U14.AP3 U14.AP10 U14.AP17 U14.AP20 U14.AP22 U14.AP23 U14.AP26 U14.AP29 U14.AP31 U14.AP38 U14.AP39 U14.AP48 U14.AP52 U14.AP54 U14.AP57 U14.AR5 U14.AR11 U14.AR15 U14.AR17 U14.AR23 U14.AR31 U14.AR33 U14.AR39 U14.AR43 U14.AR49 U14.AR52 U14.AT13 U14.AT35 U14.AT37 U14.AT40 U14.AT42 U14.AT43 U14.AT46 U14.AT49 U14.AT61 U14.AT62 U14.AT63 U14.AU1 U14.AU16 U14.AU18 U14.AU20 U14.AU22 U14.AU24 U14.AU26 U14.AU28 U14.AU30 U14.AU33 U14.AU51 U14.AU53 U14.AU55 U14.AU57 U14.AU59 U14.AV8 U14.AV14 U14.AV16 U14.AV20 U14.AV24 U14.AV28 U14.AV33 U14.AV34 U14.AV36 U14.AV39 U14.AV41 U14.AV43 U14.AV46 U14.AV49 U14.AV51 U14.AV55 U14.AV59 U14.AW4 U14.AW16 U14.AW24 U14.AW33 U14.AW35 U14.AW37 U14.AW40 U14.AW42 U14.AW44 U14.AW47 U14.AW50 U14.AW51 U14.AW59 U14.AW60 U14.AY4 U14.AY6 U14.AY11 U14.AY16 U14.AY18 U14.AY22 U14.AY24 U14.AY26 U14.AY30 U14.AY33 U14.AY51 U14.AY53 U14.AY57 U14.AY59 U14.B4 U14.B20 U14.B24 U14.B26 U14.B28 U14.B32 U14.B36 U14.B40 U14.B44 U14.B48 U14.B52 U14.B56 U14.B60 U14.C11 U14.C14 U14.C18 U14.C20 U14.C25 U14.C27 U14.C38 U14.C39 U14.C57 U14.D2 U14.D5 U14.D8 U14.D12 U14.D14 U14.D18 U14.D21 U14.D23 U14.D25 U14.D26 U14.D27 U14.D29 U14.D30 U14.D31 U14.D33 U14.D34 U14.D35 U14.D37 U14.D38 U14.D39 U14.D41 U14.D42 U14.D43 U14.D45 U14.D46 U14.D47 U14.D49 U14.D50 U14.D51 U14.D53 U14.D54 U14.D55 U14.D57 U14.D59 U14.D62 U14.D63 U14.E11 U14.E17 U14.F20 U14.F26 U14.F30 U14.F34 U14.F38 U14.F42 U14.F46 U14.F50 U14.F54 U14.F58 U14.F61 U14.G3 U14.G5 U14.G6 U14.G8 U14.G18 U14.G22 U14.H13 U14.H17 U14.H57 U14.J10 U14.J22 U14.J59 U14.J63 U14.K1 U14.K12 U14.L7 U14.L13 U14.L15 U14.L17 U14.L18 U14.L20 U14.L58 U14.L61 U14.M22 U14.N3 U14.N10 U14.N21 U14.P22 U14.P59 U14.P62 U14.P63 U14.R8 U14.R10 U14.R22 U14.T1 U14.T58 U14.U9 U14.U20 U14.U22 U14.U61 U14.V3 U14.V7 U14.V10 U14.V23 U14.V58 U14.W20 U14.W22 U14.Y10 U14.Y59 U14.Y63 U15.3 U16.1 U17.1 U18.14 U18.17 U21.4 U22.2 U23.1 U23.27 U23.49 U23.91 U23.113 U23.122 U24.4 U25.3 U25.18 U25.24 U25.31 U25.49 U25.50 U25.51 U25.52 U25.53 U25.54 U25.55 U25.56 U25.57 U25.58 VRAM1.A9 VRAM1.B1 VRAM1.B3 VRAM1.B9 VRAM1.D1 VRAM1.D8 VRAM1.E1 VRAM1.E2 VRAM1.E8 VRAM1.F9 VRAM1.G1 VRAM1.G8 VRAM1.G9 VRAM1.J2 VRAM1.J8 VRAM1.M1 VRAM1.M9 VRAM1.P1 VRAM1.P9 VRAM1.T1 VRAM1.T9 VRAM2.A9 VRAM2.B1 VRAM2.B3 VRAM2.B9 VRAM2.D1 VRAM2.D8 VRAM2.E1 VRAM2.E2 VRAM2.E8 VRAM2.F9 VRAM2.G1 VRAM2.G8 VRAM2.G9 VRAM2.J2 VRAM2.J8 VRAM2.M1 VRAM2.M9 VRAM2.P1 VRAM2.P9 VRAM2.T1 VRAM2.T9 VRAM3.A9 VRAM3.B1 VRAM3.B3 VRAM3.B9 VRAM3.D1 VRAM3.D8 VRAM3.E1 VRAM3.E2 VRAM3.E8 VRAM3.F9 VRAM3.G1 VRAM3.G8 VRAM3.G9 VRAM3.J2 VRAM3.J8 VRAM3.M1 VRAM3.M9 VRAM3.P1 VRAM3.P9 VRAM3.T1 VRAM3.T9 VRAM4.A9 VRAM4.B1 VRAM4.B3 VRAM4.B9 VRAM4.D1 VRAM4.D8 VRAM4.E1 VRAM4.E2 VRAM4.E8 VRAM4.F9 VRAM4.G1 VRAM4.G8 VRAM4.G9 VRAM4.J2 VRAM4.J8 VRAM4.M1 VRAM4.M9 VRAM4.P1 VRAM4.P9 VRAM4.T1 VRAM4.T9 Y1.2 Y1.4 Y2.2 Y2.4 Y4.2 Y4.4
PVCC2: C343.2 C350.2 C351.1 R253.2 U12.6
PVDD1: C255.2 C257.1 L12.2 U10.39
PVDD2: C261.1 C263.2 L13.2 U10.45
V5FILT: PC59.1 PR88.2 PR99.1 PU5.6 PU5.14
VCCSENSE: PR152.1 R304.1 U14.E63
VCCST_PWRGD#: Q6.2 U23.107
VCCST_PWRGD_L: Q6.3 R14.2 U14.B59
VDD10: C222.2 C223.2 C478.1 C479.1 C480.1 C481.2 C482.1 C483.1 L22.2 U6.3 U6.8 U6.22 U6.30
VSS_GPU_SENSE: PR33.1 PR189.1 U13.F1
VSSSENSE: PR156.1 R306.1 U14.E62
3DVISION: TP34.1 U13.B6
8205EN: PR106.2 PR107.1 PU4.13
8207BST: PR197.2 PU5.22
8207BSTR: PC177.1 PR197.1
8207CS: PR99.2 PU5.16
8207DRVH: PQ46.4 PU5.21
8207DRVL: PQ47.4 PU5.19
8207LX: PC177.2 PL8.1 PQ46.1 PQ46.2 PQ46.3 PQ47.5 PR200.2 PU5.20
8207S3: PC53.1 PD3.2 PR86.1 PU5.10
8207S5: PR66.1 PR82.1 PU5.11
8207TON: PR80.2 PU5.12
51622_ALERT#: PR138.1 PU9.32
51622_B-RAMP: PR16.1 PR19.2 PU9.11
51622_COMP: PC109.1 PR4.2 PR139.1 PR143.1 PU9.26
51622_CSN1: PC125.2 PC126.2 PL3.4 PR126.1 PR164.2 PU9.18
51622_CSN2: PR13.2 PR206.1 PU9.19
51622_CSP1: PC125.1 PC126.1 PR119.1 PR123.2 PR164.1 PU9.17
51622_CSP2: PC118.1 PC119.1 PR121.1 PR122.2 PR154.2 PR160.1 PU9.20
51622_DROOP: PC108.2 PC109.2 PR143.2 PU9.25
51622_F-IMAX: PR17.1 PR20.2 PU9.10
51622_GFB: PR156.2 PU9.23
51622_IMON: PC136.1 PR166.1 PU9.13
51622_O-USR: PR18.1 PR21.2 PU9.9
51622_OCP-I: PR166.2 PR170.1 PU9.12
51622_PWM1: PQ26.8 PU9.6
51622_PWM2: PQ24.8 PU9.5
51622_SKIP#: PR161.1 PR163.1 PU9.7
51622_THERM: PC137.1 PR171.1 PR172.2 PU9.14
51622_V5A: PC105.1 PR132.1 PU9.28
51622_VCLK: PR10.2 PR142.1 PU9.31
51622_VDIO: PR6.2 PR137.1 PU9.1
51622_VDO: PC113.1 PR153.1 PU9.2
51622_VFB: PR152.2 PU9.24
51622_VR_HOT: PR145.1 PU9.30
51622_VR_ON: PR162.1 PR165.1 PU9.8
51622_VREF: PC107.1 PR4.1 PR19.1 PR20.1 PR21.1 PR167.2 PR172.1 PU9.27
81172_COMP: PC29.1 PR40.2 PU1.12
81172_FB: PC29.2 PC30.2 PR43.1 PR44.1 PU1.11
81172_FBRTN: PC166.1 PR189.2 PU1.10
81172_HG1: PQ40.4 PU1.2
81172_HG2: PQ38.4 PU1.17
81172_LG1: PQ39.4 PR45.1 PU1.23
81172_LG2: PQ36.4 PU1.20
81172_PH1: PC35.1 PL6.1 PQ39.5 PQ40.1 PQ40.2 PQ40.3 PR186.2 PU1.24
81172_PH2: PC28.1 PL5.1 PQ36.5 PQ38.1 PQ38.2 PQ38.3 PR184.2 PU1.19
81172_VREF: PC33.1 PR37.2 PR47.1 PU1.8
81172GND: PC26.2 PC27.2 PC33.2 PC34.2 PR38.2 PR42.2 PR51.2 PR52.1 PU1.25
+CARD_3V3: C279.1 C497.1 CN9.6 U9.12
+DC_IN: EC14.1 EL5.2 PC138.1 PQ31.3 PQ32.1 PQ32.2 PQ32.3 PR22.1 PR173.1
+DC_IN_SS: PC139.1 PC140.1 PD5.2 PQ32.5 PQ32.6 PQ32.7 PQ32.8 PQ35.5 PQ35.6 PQ35.7 PQ35.8 PR26.1 PR27.1 PR94.1 PR424.1
+DCIN_JACK: CN2.1 EC2.1 EC3.1 EC4.1 EL5.1
+DCPSUSBYP: C150.1 C525.2 U14.AG19 U14.AG20
+DDR_VTT: C241.1 C248.1 C277.1 C287.1 C305.2 C317.2 JDIM1.203 JDIM1.204 PC68.1 PC71.1 PU5.2 PU5.24 R481.1
+FB_PLLAVDD: C96.2 C138.1 C142.2 L3.1 U13.F16 U13.H22 U13.P22
+LCDVCC: C495.1 C496.1 C499.1 CN11.1 CN11.2 U22.1
+LED_BL: C509.1 C515.1 CN11.27 CN11.28 CN11.29 CN11.30 Q28.3
+RTC_1: RTCBT1.1 RTCR1.2
+RTC_2: RTCD1.1 RTCR1.1
+RTC_CELL: C155.2 C195.2 C196.1 C401.1 C511.2 R119.2 R120.1 R405.2 R406.2 R407.1 RTCD1.3 U14.AG10 U23.3
+SMDDR_VREF_CA: C292.1 C295.1 C296.1 C297.1 JDIM1.126 R200.1 R201.2 R202.2
+SMDDR_VREF_DQA: C221.1 C233.1 C243.1 C252.1 JDIM1.1 R158.2 R161.2 R166.1
+USB_SIDE0_PWR: C201.1 C202.1 C466.1 CN5.1 U16.6 U16.7 U16.8
+USB_SIDE1_PWR: C166.1 C167.1 C441.1 CN4.1 U17.6 U17.7 U17.8
+USB_SIDE2_PWR: C203.1 C204.1 C470.1 CN6.1 U18.12
+V_VDDQ: C226.2 C227.2 C228.1 C229.1 C230.2 C231.1 C232.1 C293.1 C294.1 C300.2 C301.2 C302.2 C303.2 JDIM1.75 JDIM1.76 JDIM1.81 JDIM1.82 JDIM1.87 JDIM1.88 JDIM1.93 JDIM1.94 JDIM1.99 JDIM1.100 JDIM1.105 JDIM1.106 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 PC21.2 PC77.1 PC173.1 PC174.1 PL8.2 PQ7.5 PR195.2 PU5.8 PU5.23 R140.2 R148.1 R154.1 R166.2 R200.2 R440.1
+V_VDDQ_CPU: C143.2 C144.2 C145.1 C146.1 C451.1 C452.1 C453.1 C454.1 C455.1 C456.1 C539.2 C540.2 R440.2 U14.AH26 U14.AJ31 U14.AJ33 U14.AJ37 U14.AN33 U14.AP43 U14.AR48 U14.AY35 U14.AY40 U14.AY44 U14.AY50
+V_VREF_VD1: C215.2 R152.1 R158.1
+VCHGR: CN18.1 CN18.2 PC191.1 PC197.1 PC198.1 PC200.1 PQ20.5 PQ20.6 PQ20.7 PQ20.8 PR114.2 PR118.1 PR201.2
+VGACORE: C41.2 C48.2 C58.2 C59.2 C61.2 C65.2 C68.2 C80.2 C85.2 C86.2 C89.2 C93.2 C99.2 C100.2 C101.2 C112.2 C113.2 C169.2 C172.2 C175.2 C186.2 C187.2 C189.2 C192.2 C463.2 C464.2 D3.2 PC22.2 PC23.1 PC24.1 PC25.1 PC142.1 PC143.2 PL5.2 PL6.2 PR29.1 PR31.1 U13.K10 U13.K12 U13.K14 U13.K16 U13.K18 U13.L11 U13.L13 U13.L15 U13.L17 U13.M10 U13.M12 U13.M14 U13.M16 U13.M18 U13.N11 U13.N13 U13.N15 U13.N17 U13.P10 U13.P12 U13.P14 U13.P16 U13.P18 U13.R11 U13.R13 U13.R15 U13.R17 U13.T10 U13.T12 U13.T14 U13.T16 U13.T18 U13.U11 U13.U13 U13.U15 U13.U17 U13.V10 U13.V12 U13.V14 U13.V16 U13.V18
+VH28: PC78.1 PU6.17
AC_OFF: PQ5.2 PR23.2 U23.69
AC_OK: PQ6.2 PQ16.6 PR180.1
AC_PRESENT: R78.1 U14.AJ8 U23.112
ACAV_IN: D12.1 PQ16.2 PQ16.3 PR102.1 PR104.2 Q33.2
ACN: PC61.1 PC75.1 PR183.2P PU3.1
ACP: PC61.2 PC76.1 PR183.1P PU3.2
ACZ_SPKR: C354.1 U14.V2
ADSP_SIN0: TP70.1 U7.28
ADSP_SOUT0: TP69.1 U7.29
ALERT: R98.1 U13.F8
ALW_ON: PQ15.2 Q32.2 U23.83
AMP_BEEP: R379.2 U10.12
AP_24M: R117.2 U7.7
AP_DIGITAL_CLK: R194.2 U7.4
AP_DIGITAL_D1: R215.2 U7.3
AP_I2S_DIN: R263.1 U7.33
AP_I2S_DOUT: R211.1 U7.32
APWROK: R62.1 U23.128
APWROK_R: R60.1 R62.2 U14.AB5
AUDIO_I2S_BCLK: R262.2 U10.16
AUDIO_I2S_DIN: R211.2 U10.24
AUDIO_I2S_DOUT: R263.2 U10.17
AUDIO_I2S_LRCK: R264.2 U10.18
AUDIO_PWR_EN: R314.2 U14.P1
B_TEMP_MBAT: CN18.3 ESD6.6 PC199.2 PR204.1 PR205.1
BAT_LED_AMBER: LED2.1 U23.30
BATDIS_ID_DOD: PQ17.3 PQ20.4 PR109.2
BATLOW#_R: LED2.2 R2.1
BATSHIP: PQ22.2 U23.2
BBS: R24.2 R25.1 U14.L8
BEEP: C345.1 U23.34
BID0: R442.1 R443.1 U23.66
BID1: R447.1 R448.1 U23.71
BQ24707_ILIM: PC47.1 PR64.1 PR65.1 PR67.1 PU3.10
BREATH_LED: Q1.2 U23.24
BREATH_PWRLED#: LED1.1 Q1.3
BT_RADIO_DIS#: CN14.54 U14.R7
BT_WAKE#: R123.1 U14.AM3
BUF_PLT_RST#: R114.2 R135.1 U15.4 U23.22
BXTALOUT: R382.1 U13.C10
CARD_+3.3V_EN: R354.1 U14.AL2
CATERR#: TP44.1 U14.K61
CBN: C274.2 U10.35
CBP: C274.1 U10.36
CEXT: C532.1 U25.2
CFG: R357.2 U2.23
CFG0: R339.1 U14.AC60
CFG0_8330: R507.1 R510.1 U25.5
CFG1: R334.1 U14.AC62
CFG1_8330: R508.1 R511.1 U25.40
CFG3: R330.1 TP25.1 U14.AA63
CFG4: R61.1 U14.AA60
CFG5: TP26.1 U14.Y62
CFG6: TP8.1 U14.Y61
CFG7: TP7.1 U14.Y60
CFG8: R326.1 U14.V62
CFG9: R58.1 U14.V61
CFG10: R57.1 U14.V60
CFG11: TP24.1 U14.U60
CFG12: TP20.1 U14.T63
CFG13: TP22.1 U14.T62
CFG14: TP5.1 U14.T61
CFG15: TP6.1 U14.T60
CLK_27M_XTAL_IN: C445.2 U13.C11 Y2.3
CLK_27M_XTAL_OUT: C446.2 U13.B10 Y2.1
CLK_LPC_DEBUG_R: CN14.71 R233.2
CLK_PCIE_CR_N: U9.6 U14.B41
CLK_PCIE_CR_P: U9.5 U14.A41
CLK_PCIE_LANN: U6.16 U14.C41
CLK_PCIE_LANP: U6.15 U14.B42
CLK_PCIE_VGAN: U13.AD8 U14.A39
CLK_PCIE_VGAP: U13.AE8 U14.B39
CLK_PCIE_WLANN: CN14.49 U14.B38
CLK_PCIE_WLANP: CN14.47 U14.C37
CLKREQ_C1: Q8.3 Q9.2 R104.1 R113.2
CLKRUN#: R43.1 U14.V5 U23.93
CMPIN: PR108.2 PR110.1 PR111.1 PU3.4
CMPOUT: PR110.2 PR112.1 PR115.2 PR428.1 PU3.3
COMBOJACK: C352.2 Q48.2 R268.1
CR_CLKREQ#: R230.1 R243.1 U9.2
CR_RST#: R229.1 U9.1
DC_TEST_A3_B3: U14.A3 U14.B3
DC_TEST_A61_B61: U14.A61 U14.B61
DC_TEST_AY2_AW2: U14.AW2 U14.AY2
DC_TEST_AY3_AW3: U14.AW3 U14.AY3
DC_TEST_AY61_AW61: U14.AW61 U14.AY61
DC_TEST_AY62_AW62: U14.AW62 U14.AY62
DC_TEST_B62_B63: U14.B62 U14.B63
DC_TEST_C1_C2: U14.C1 U14.C2
DCAP: PC73.2 PU6.16
DCIN_EN: R91.2 U2.13
DDCBUF: R367.1 R370.2 U2.14
DDR3_DRAMRST#: JDIM1.30 R140.1 U14.AV15
DDR_PG_CTRL: PR39.1 Q18.2 Q19.3 Q44.2 R150.2 R151.2 U5.4
DDR_PWRGD: PU5.13 R196.2
DDR_VTTREF: PC62.2 PU5.5
DEVSLP1: R275.1 R307.1 U14.L2
DEVSLP1_R: CN17.10 R275.2
DEVSLP2: R34.1 U14.N5
DGPU_EDIDCLK: R373.2 U13.A9
DGPU_EDIDDATA: R374.2 U13.B9
DGPU_HOLD_RST#: R50.1 U1.1 U14.P3
DGPU_OVT#: Q39.3 R157.1
DGPU_PGOK-1: C461.1 Q35.3 Q36.2 R399.1
DGPU_POK2: C462.1 Q38.2 R398.1
DGPU_POK4: C448.1 Q35.2 R386.1
DGPU_PR_EN_G: PQ18.3 PQ29.2 PQ37.2 PR100.2 PR101.1
DGPU_PSI: PR60.2 U13.B4
DGPU_PWM_VID: PR55.2 U13.E7
DGPU_PWR_EN: PD4.1 PR54.1 PR105.1 R36.1 U14.L3
DGPU_PWROK: D8.1 Q36.3 R113.1 R371.1 R377.2
DGPU_VC_EN: PD1.2 PD7.1 PR36.2 PR190.2 PU1.16
DIGITAL_CLK: C31.2 C276.1 L6.1 R194.1 R195.1
DIGITAL_CLK2_R: C32.2 CN1.11 L6.2 R26.1
DIGITAL_CLK_R: CN1.8 R26.2
DIGITAL_D1: C34.2 C314.1 L7.1 R214.1 R215.1
DIGITAL_D1_R: CN1.9 R29.2
DIGITAL_D2_R: C35.2 CN1.12 L7.2 R29.1
DIMM1_SA0: JDIM1.197 R164.1
DIMM1_SA1: JDIM1.201 R165.1
DMIC_CLK_R: R195.2 U10.2
DMIC_D1_R: R214.2 U10.4
DP_ENVDD: D18.1 R235.1 U14.C6
DP_UTIL: R290.1 R291.1 U14.A43
DPWROK: R403.2 U23.106
DPWROK_R: R389.1 R390.1 R403.1 U14.AV5
DSP_GPIO: R528.1 U7.27 U10.46
DSP_I2C_CK: Q20.1 R171.2 R466.1 U7.6
DSP_I2C_DA: Q20.4 R173.2 R484.1 U7.5
DSP_PLTRST#: R450.1 U7.31
DSP_RST#: R28.1 U14.L6
DSWVRMEN: R406.1 U14.AW7
EARP_L: L14.1 R217.1
EARP_L1: C270.1 C284.1 CN12.1 L14.2
EARP_L2: R217.2 U10.31
EARP_R: L15.1 R210.1
EARP_R1: C337.1 C341.1 CN12.2 L15.2
EARP_R2: R210.2 U10.32
EC_CS_EXT: R182.2 U14.L5
EC_DSP_RST#: R450.2 U23.79
EC_PWROK: R128.2 R391.1 U23.82
EC_PWROK_R: R391.2 U14.AY7
EC_RTC_RST: Q47.2 R519.1 U23.119
EC_SPI_CLK: R457.1 U23.97
EC_SPI_CS0#: R204.1 U23.96
EC_SPI_CS#: U23.101 U24.1
EC_SPI_DIN: U23.102 U24.5
EC_SPI_DO: U23.103 U24.2
EC_SPI_SI: R463.1 U23.99
EC_SPI_SLK: U23.105 U24.6
EC_SPI_SO: R186.1 R192.2
EC_SPI_SO_R: R192.1 U23.98
EC_WAKE#: R134.2 U23.70
EDP_AUXN: C320.2 U14.A45
EDP_AUXN_C: C320.1 U25.29
EDP_AUXN_R: C542.1 CN11.8
EDP_AUXN_RC: C542.2 R505.2 U25.27
EDP_AUXP: C309.2 U14.B45
EDP_AUXP_C: C309.1 U25.30
EDP_AUXP_R: C541.1 CN11.7
EDP_AUXP_RC: C541.2 R506.2 U25.28
EDP_BL_EN: D22.1 U14.A9 U23.120
EDP_COMP: R22.1 U14.D20
EDP_HP_R: R16.1 R17.1 U14.D6
EDP_HPD: CN11.5 R16.2 R517.2
EDP_TXN0: C282.2 U14.C45
EDP_TXN0_C: C282.1 U25.39
EDP_TXN0_R: C528.2 U25.22
EDP_TXN0_RC: C528.1 EL14.3
EDP_TXN0_RL: CN11.11 EL14.4
EDP_TXN1: C280.2 U14.A47
EDP_TXN1_C: C280.1 U25.42
EDP_TXN1_R: C530.2 U25.19
EDP_TXN1_RC: C530.1 EL13.3
EDP_TXN1_RL: CN11.14 EL13.4
EDP_TXP0: C283.2 U14.B46
EDP_TXP0_C: C283.1 U25.38
EDP_TXP0_R: C529.2 U25.23
EDP_TXP0_RC: C529.1 EL14.2
EDP_TXP0_RL: CN11.10 EL14.1
EDP_TXP1: C281.2 U14.B47
EDP_TXP1_C: C281.1 U25.41
EDP_TXP1_R: C531.2 U25.20
EDP_TXP1_RC: C531.1 EL13.2
EDP_TXP1_RL: CN11.13 EL13.1
EN_LCDVCC: D18.3 R464.1 U22.3
ENTRIP1: PQ14.3 PR85.2 PU4.1
ENTRIP2: PQ13.3 PR79.1 PU4.6
EQ: R76.1 R79.2 U2.17
EXT_MIC_1: C353.2 C360.1 CN12.4 L16.2 R268.2
EXT_MIC_2: C323.1 C326.2 R227.2
EXT_MIC_L1: C326.1 U10.28
EXT_MIC_R: L16.1 R227.1 R267.1 R270.2
EXT_MIC_R1: C323.2 U10.29
FAN1_PWM: FAN1.2 U23.28
FAN1_TACH: FAN1.4 R425.1 U23.47
FAN2_PWM: FAN2.2 U23.25
FAN2_TACH: FAN2.4 R422.1 U23.48
FB_CAL_PD_VDDQ: R80.2 U13.D22
FB_CAL_PU_GND: R73.2 U13.C24
FB_CAL_TERM_GND: R359.2 U13.B25
FB_CLAMP_MON: R71.1 U13.C6
FB_CLAMP_TGL_R_REQ#: R181.2 U23.17
FB_CLAMP_TGL_REQ#: R8.1 R181.1 U13.A4
FB_VREF_PROBE: TP9.1 U13.D23
FBA_DEBUG: R68.2 U13.F22
FBA_DEBUG1: R64.2 U13.J22
FIVR_EN_BUF: R37.1 U14.H59
G5934CN: PC80.2 PU6.19
G5934CP: PC80.1 PU6.18
G5934VIN: PC81.2 PR117.1 PU6.20
GFX_SCL: Q14.4 R127.1 U13.D9
GFX_SDA: Q14.1 R126.1 U13.D8
GPIO8: R358.1 U14.AU2
GPIO15: R65.1 U14.AD6
GPIO17: D8.2 R45.1 U14.T3
GPIO24: R69.1 U14.AD5
GPIO28: R66.1 U14.AD7
GPIO33: R310.1 U14.P2
GPIO35: R319.1 U14.U1
GPIO36: R46.1 U14.V6
GPIO37: R328.1 U14.AC1
GPIO91: RP16.2 U14.J1
GPIO92: RP16.4 U14.K3
GPIO93: RP15.4 U14.J2
GPIO94: RP15.2 U14.G1
GPU_GPIO16: TP30.1 U13.D5
GSPI_CS: R42.1 U14.R6
H_CPU_SVIDALRT#: R312.1 U14.L62
H_CPUPWRGD: R13.2 U14.C61
H_PROCHOT#: R309.2 U14.K63
H_PROCHOT_EC: Q43.2 R469.1 U23.86
H_VR_ENABLE_MCP: PR165.2 R9.2 R18.1 U14.F60
HD_SDIN0: R232.2 U10.8
HDA_BEEP2: R258.2 R379.1
HDA_BITCLK: C321.1 R411.1 U10.6
HDA_BITCLK_L: C460.1 R394.1 R411.2
HDA_BITCLK_R: R394.2 U14.AW8
HDA_RST#: R393.1 U10.11
HDA_RST#_R: R393.2 U14.AU8
HDA_SDIN0: R232.1 U14.AY10
HDA_SDOUT: C322.1 R408.1 U10.5
HDA_SDOUT_R: R395.2 R408.2 U14.AU11
HDA_SYNC: C335.2 R409.1 U10.10
HDA_SYNC_R: R396.2 R409.2 U14.AV11
HDMI_CLK_SINK: CN3.15 RP18.2 U2.32
HDMI_DAT_SINK: CN3.16 RP18.4 U2.33
HDMI_PD#_LPT: R32.1 R75.1 U14.N6
HDMI_SCL: RP2.1 U2.38 U14.B9
HDMI_SDA: RP2.3 U2.39 U14.C9
HDMI_SINK: CN3.19 Q40.2 U2.28
HPD_HDMI_PD#: Q40.3 R82.1 R384.1
HSPI_CS#: R176.2 R179.2 R204.2
HWPG: C269.1 PD6.2 R189.1 R196.1 R205.1 U23.109
I2C_CK0: RP4.2 U14.F3
I2C_CK1: R478.1 RP14.2 U14.F1
I2C_DA0: RP4.4 U14.F2
I2C_DA1: R477.1 RP14.4 U14.G4
I2CA_SCL: R375.1 U13.B7
I2CA_SDA: R376.1 U13.A7
I2S_BCLK: C359.2 R262.1 U7.35
I2S_LRCK_FS: R264.1 U7.34
IINP: PC57.1 PR193.1 PU3.7 U23.72
IMVP7_PROCHOT#: PQ21.3 PQ50.3 PR145.2 Q43.3 R309.1 R311.1 R317.1
IMVP_PWRGD: D1.2 PR11.1 PU9.3 R491.1
IMVP_VR_ON: PR162.2 R467.1 U23.16
INT_HDMI_HP: R287.2 U2.3 U14.C8
INT_HDMI_TXCN: C185.1 U14.A57
INT_HDMI_TXCN_C: C185.2 U2.10
INT_HDMI_TXCN_L: CN3.12 EL4.3 R59.2
INT_HDMI_TXCN_R: EL4.4 U2.21
INT_HDMI_TXCP: C184.1 U14.B57
INT_HDMI_TXCP_C: C184.2 U2.9
INT_HDMI_TXCP_L: CN3.10 EL4.2 R59.1
INT_HDMI_TXCP_R: EL4.1 U2.22
INT_HDMI_TXN0: C183.1 U14.B55
INT_HDMI_TXN0_C: C183.2 U2.7
INT_HDMI_TXN0_L: CN3.9 EL3.3 R55.2
INT_HDMI_TXN0_R: EL3.4 U2.24
INT_HDMI_TXN1: C181.1 U14.B58
INT_HDMI_TXN1_C: C181.2 U2.5
INT_HDMI_TXN1_L: CN3.6 EL2.3 R52.2
INT_HDMI_TXN1_R: EL2.4 U2.26
INT_HDMI_TXN2: C179.1 U14.C54
INT_HDMI_TXN2_C: C179.2 U2.2
INT_HDMI_TXN2_L: CN3.3 EL1.3 R44.2
INT_HDMI_TXN2_R: EL1.4 U2.29
INT_HDMI_TXP0: C182.1 U14.A55
INT_HDMI_TXP0_C: C182.2 U2.6
INT_HDMI_TXP0_L: CN3.7 EL3.2 R55.1
INT_HDMI_TXP0_R: EL3.1 U2.25
INT_HDMI_TXP1: C180.1 U14.C58
INT_HDMI_TXP1_C: C180.2 U2.4
INT_HDMI_TXP1_L: CN3.4 EL2.2 R52.1
INT_HDMI_TXP1_R: EL2.1 U2.27
INT_HDMI_TXP2: C178.1 U14.C55
INT_HDMI_TXP2_C: C178.2 U2.1
INT_HDMI_TXP2_L: CN3.1 EL1.2 R44.1
INT_HDMI_TXP2_R: EL1.1 U2.30
IRQ_SERIRQ: R38.1 U14.T4 U23.5
ISET: R380.2 R383.1 U2.34
JTAG_TCK: TP18.1 U13.AE5
JTAG_TDI: TP16.1 U13.AE6
JTAG_TDO: TP15.1 U13.AF6
JTAG_TMS: TP19.1 U13.AD6
JTAG_TRST#: R295.1 U13.AG4
KB_DET#: R322.1 U14.Y1
L_SPK+: L29.2 U10.40
L_SPK+_R: C507.2 CN10.3 L29.1
L_SPK-: L28.2 U10.41
L_SPK-_R: C505.2 CN10.4 L28.1
LAN_CLKREQ#: Q42.3 R445.1 R446.2 U6.12
LAN_ISOLAT#: R435.1 R436.1 U6.20
LAN_LED0: TP37.1 U6.27
LAN_LED1: TP36.1 U6.26
LAN_LED2: TP13.1 U6.25
LAN_MCTG: C469.2 R145.2 R147.2 R156.2 R159.2
LAN_MCTG0: R145.1 U19.15
LAN_MCTG1: R147.1 U19.16
LAN_MCTG2: R156.1 U19.21
LAN_MCTG3: R159.1 U19.22
LAN_MX0+: CN7.1 U19.24
LAN_MX0-: CN7.2 U19.23
LAN_MX1+: CN7.3 U19.20
LAN_MX1-: CN7.6 U19.19
LAN_MX2+: CN7.4 U19.18
LAN_MX2-: CN7.5 U19.17
LAN_MX3+: CN7.7 U19.14
LAN_MX3-: CN7.8 U19.13
LAN_PWR_EN_EC: PR61.1 U23.87
LAN_PWR_EN_EC_R: PC39.1 PR61.2 PU2.3
LAN_RST#: R431.2 R433.2 U6.19
LAN_XTALI: C239.1 U6.28 Y4.3
LAN_XTALO: C240.1 U6.29 Y4.1
LATCH: C397.1 D4.1 D7.1 Q32.5 Q32.6 Q33.3 R280.1
LCD_BAK: CN11.24 D22.2 R525.1 U23.35
LCD_BAK_IN: D22.3 R502.2 R525.2
LCD_BL_PWM: TP33.1 U13.D6
LCD_BLEN: TP11.1 U13.F9
LCD_DBC: R337.1 R480.2 U14.AB6
LCD_DBC_R: CN11.22 R480.1
LCD_PWM: D17.1 R291.2 R293.1
LCD_PWM_EC: D17.2 U23.29
LCD_PWM_IN: CN11.23 D17.3 R454.1
LCD_TST: CN11.21 D18.2 R216.1
LCD_TST_R: R216.2 U23.126
LCD_VCC: TP10.1 U13.C7
LID_SW#: C13.2 HE1.1 R221.1 U23.88
LPC_CLK_0: R410.1 U14.AN15
LPC_CLK_1: R116.1 R117.1 U14.AP15
LPC_CLK_DEBUG: R116.2 R233.1
LPC_CLK_EC: EC5.1 R223.2 R410.2 U23.13
LPC_LAD0: R489.2 U14.AU14 U23.10
LPC_LAD0_R: CN14.64 R489.1
LPC_LAD1: R488.2 U14.AW12 U23.9
LPC_LAD1_R: CN14.66 R488.1
LPC_LAD2: R487.2 U14.AY12 U23.8
LPC_LAD2_R: CN14.68 R487.1
LPC_LAD3: R486.2 U14.AW11 U23.7
LPC_LAD3_R: CN14.70 R486.1
LPC_LFRAME#: R485.1 U14.AV12 U23.6
LPC_LFRAME#_R: CN14.73 R485.2
LPT_CR_RST#: R74.1 U14.AG6
LPT_DDR_PG_CTRL: R143.1 U14.AV61
LPT_LAN_RST#: R77.1 U14.AG5
M_B_A0: JDIM1.98 U14.AP40
M_B_A1: JDIM1.97 U14.AR40
M_B_A2: JDIM1.96 U14.AP42
M_B_A3: JDIM1.95 U14.AR42
M_B_A4: JDIM1.92 U14.AR45
M_B_A5: JDIM1.91 U14.AP45
M_B_A6: JDIM1.90 U14.AW46
M_B_A7: JDIM1.86 U14.AY46
M_B_A8: JDIM1.89 U14.AY47
M_B_A9: JDIM1.85 U14.AU46
M_B_A10: JDIM1.107 U14.AK36
M_B_A11: JDIM1.84 U14.AV47
M_B_A12: JDIM1.83 U14.AU47
M_B_A13: JDIM1.119 U14.AK33
M_B_A14: JDIM1.80 U14.AR46
M_B_A15: JDIM1.78 U14.AP46
M_B_BS#0: JDIM1.109 U14.AL35
M_B_BS#1: JDIM1.108 U14.AM36
M_B_BS#2: JDIM1.79 U14.AU49
M_B_CAS#: JDIM1.115 U14.AM33
M_B_CKE0: JDIM1.73 U14.AY49
M_B_CKE1: JDIM1.74 U14.AU50
M_B_CLKN0: JDIM1.103 U14.AM38
M_B_CLKN1: JDIM1.104 U14.AK38
M_B_CLKP0: JDIM1.101 U14.AN38
M_B_CLKP1: JDIM1.102 U14.AL38
M_B_CS#0: JDIM1.114 U14.AM32
M_B_CS#1: JDIM1.121 U14.AK32
M_B_DQ0: JDIM1.4 U14.AY31
M_B_DQ1: JDIM1.6 U14.AW31
M_B_DQ2: JDIM1.17 U14.AY29
M_B_DQ3: JDIM1.15 U14.AW29
M_B_DQ4: JDIM1.7 U14.AV31
M_B_DQ5: JDIM1.5 U14.AU31
M_B_DQ6: JDIM1.16 U14.AV29
M_B_DQ7: JDIM1.18 U14.AU29
M_B_DQ8: JDIM1.22 U14.AY27
M_B_DQ9: JDIM1.21 U14.AW27
M_B_DQ10: JDIM1.35 U14.AY25
M_B_DQ11: JDIM1.34 U14.AW25
M_B_DQ12: JDIM1.24 U14.AV27
M_B_DQ13: JDIM1.23 U14.AU27
M_B_DQ14: JDIM1.33 U14.AV25
M_B_DQ15: JDIM1.36 U14.AU25
M_B_DQ16: JDIM1.42 U14.AM29
M_B_DQ17: JDIM1.40 U14.AK29
M_B_DQ18: JDIM1.51 U14.AL28
M_B_DQ19: JDIM1.50 U14.AK28
M_B_DQ20: JDIM1.39 U14.AR29
M_B_DQ21: JDIM1.41 U14.AN29
M_B_DQ22: JDIM1.53 U14.AR28
M_B_DQ23: JDIM1.52 U14.AP28
M_B_DQ24: JDIM1.58 U14.AN26
M_B_DQ25: JDIM1.57 U14.AR26
M_B_DQ26: JDIM1.69 U14.AR25
M_B_DQ27: JDIM1.67 U14.AP25
M_B_DQ28: JDIM1.56 U14.AK26
M_B_DQ29: JDIM1.59 U14.AM26
M_B_DQ30: JDIM1.70 U14.AK25
M_B_DQ31: JDIM1.68 U14.AL25
M_B_DQ32: JDIM1.132 U14.AY23
M_B_DQ33: JDIM1.130 U14.AW23
M_B_DQ34: JDIM1.143 U14.AY21
M_B_DQ35: JDIM1.141 U14.AW21
M_B_DQ36: JDIM1.129 U14.AV23
M_B_DQ37: JDIM1.131 U14.AU23
M_B_DQ38: JDIM1.142 U14.AV21
M_B_DQ39: JDIM1.140 U14.AU21
M_B_DQ40: JDIM1.149 U14.AY19
M_B_DQ41: JDIM1.148 U14.AW19
M_B_DQ42: JDIM1.157 U14.AY17
M_B_DQ43: JDIM1.159 U14.AW17
M_B_DQ44: JDIM1.147 U14.AV19
M_B_DQ45: JDIM1.146 U14.AU19
