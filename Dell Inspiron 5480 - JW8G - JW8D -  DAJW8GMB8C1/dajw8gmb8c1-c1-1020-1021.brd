# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_CLK_REQ3#: length 135.7
  TOP w0.102: v1(91.07,35.19) 91.07,34.21 R501.1 ; v2(92.31,33.9) 92.18,33.9 91.96,34.12 R501.1 ; Q45.6 91.92,32.94 91.15,33.71 R501.1
  IN3 w0.076: v2(161.47,95.04) 161.47,94.68 161.31,94.53 160.14,94.53 159.9,94.28 159.9,94.02 159.29,93.42 157.99,93.42 157.97,93.41 157.51,93.41 157.5,93.42 157.35,93.42 157.34,93.41 156.88,93.41 156.87,93.42 156.72,93.42 156.71,93.41 155.9,93.41 155.9,93.41 155.57,93.41 155.57,93.41 155.51,93.41 155.5,93.42 155.08,93.42 154.46,92.8 154.05,92.8
  IN3 w0.114: v2(167.51,99.54) 166.48,99.54 163.56,96.62 163.56,96.43 163.56,95.41 163,94.86 162.34,94.86 162.16,95.04 v2(161.47,95.04) ; v2(92.31,33.9) 92.82,34.4 94.22,34.4 95.61,33.01 101.37,33.01 105.45,37.1 105.45,46.51 109.91,50.97 109.91,51.65 113.46,55.2 113.46,60.07 113.28,60.25 113.28,67.55 114.23,68.5 114.23,72.92 119.44,78.12 119.44,85.84 119.92,86.32 121.22,86.32 121.9,87.01 121.9,88.23 122.69,89.01 124.21,89.01 124.97,89.77 126.21,89.77 126.36,89.93 127.31,89.93 127.46,90.08 130.64,90.08 133.59,93.03 141.82,93.03 141.86,93.08 146.67,93.08 147.91,91.83 148.58,91.83 150.23,93.48 153.04,93.48 153.73,92.8 154.05,92.8
  BOTTOM w0.076: U14.N1 160.27,94.64 161.07,94.64 v2(161.47,95.04)
  BOTTOM w0.102: v2(167.51,99.54) 167.49,99.54 167.9,99.96 168.64,99.96 168.97,99.63 RN1.7
PCIE_CLK_REQ3#_R_L: length 9.3
  TOP w0.102: v1(87.59,31.2) 87.59,31.25 87.74,31.41 88.55,31.41 88.93,31.02 88.93,29.58 89.09,29.42 90.2,29.42 90.54,29.09 ; 90.8,29.58 90.54,29.32 90.54,29.09 ; 90.8,29.58 Q46.3 ; 90.8,29.58 91.18,29.2 92.44,29.2 92.57,29.32 Q45.2 ; 90.54,29.09 R500.2
PCIE_CLK_REQ4#: length 56.5
  TOP w0.102: Q9.3 180.35,71.61 v2(179.03,71.61)
  IN2 w0.114: v2(179.03,71.61) 177.42,73.23 177.42,74.99 177.28,75.13 177.28,76.96 176.34,77.91 176.34,87.03 178.27,88.97 178.27,90.68 177.02,91.93 177.02,92.65 177.01,92.66 177.01,94.09 176.78,94.32 176.78,95.96 173.6,99.15 168.83,99.15 168.54,98.86 v2(168.54,97.6)
  IN3 w0.076: v2(157.68,93.01) 157.68,93.02 158.1,92.61 158.1,92.48 158.33,92.25 158.79,92.25 158.81,92.23
  IN3 w0.114: v2(168.54,97.6) 168.95,97.19 168.95,96.14 168.73,95.93 165.75,95.93 163.19,93.36 163.19,93.08 162.8,92.69 160.25,92.69 159.79,92.23 158.81,92.23
  BOTTOM w0.102: v2(168.54,97.6) 168.54,97.04 168.86,96.72 RP17.3 ; v2(157.68,93.01) 157.68,93.02 157.51,92.84 U14.U5
PCIE_CLK_REQ5#: length 12.8
  IN3 w0.114: v2(161.7,93.42) 162.15,92.97 162.53,92.97 162.87,93.3 162.87,93.43 166.32,96.88 167.98,96.88 v2(168.51,96.35)
  BOTTOM w0.076: v2(161.7,93.42) 161.7,93.43 161.7,93.44 161.7,93.61 161.51,93.81 160.83,93.81 160.33,93.31 160.02,93.31 159.98,93.27 159.65,93.27 159.49,93.12 U14.T2
  BOTTOM w0.102: v2(168.51,96.35) 168.8,96.07 RP17.1
PCIE_CR_WAKE#: length 13
  TOP w0.102: v2(55.86,28.18) 56.5,28.18 Q30.1 ; U9.32 55.67,36.36 54.72,35.42 v2(54.08,35.42) 54.08,36.24 53.76,36.56 R199.2
  IN3 w0.114: v2(55.86,28.18) 55.51,28.18 54.34,29.35 54.34,35.17 v2(54.08,35.42)
PCIE_EC_WAKE#: length 257.7
  TOP w0.102: v2(56.5,26.53) 56.62,26.53 56.73,26.43 Q30.3
  IN3 w0.114: v2(56.5,26.53) 56.75,26.53 57.39,25.89 67.39,25.89 68.41,24.88 70.69,24.88 71.5,25.68 74.41,25.68 75.61,24.49 84.39,24.49 85.18,25.28 87.58,25.28 89.45,27.16 90.48,27.16 92.13,28.82 102.17,28.82 109.87,36.52 118.68,36.52 119.34,35.86 137.79,35.86 138.44,36.51 152.33,36.51 152.93,37.11 155.22,37.11 155.44,36.88 184.27,36.88 188.18,32.97 191.42,32.97 193.46,30.94 196.83,30.94 198.95,30.94 199.07,30.82 199.69,30.2 199.79,30.1 208.78,30.1 209.56,29.32 209.79,29.32 209.79,29.32 210.34,29.32 211.21,28.46 219.16,28.46 219.95,29.25 v2(219.95,29.3) 220.38,28.87 222.31,28.87 222.94,29.5 226.96,29.5 227.27,29.82 229.24,29.82 229.54,29.82 230.03,30.31 230.39,30.31 232.76,30.31 234.33,28.74 236.25,28.74 236.83,28.17 240.28,28.17 240.72,28.61 v2(242.3,28.61)
  BOTTOM w0.102: U23.33 221.49,43.78 223.6,41.67 223.6,40.02 221.47,37.88 221.47,34.31 221.62,34.16 221.83,33.95 221.83,32.17 219.95,30.29 v2(219.95,29.3) ; v2(242.3,28.61) 242.29,28.61 242.29,31.09 243.57,32.37 244.61,32.37 245.47,33.23 245.47,37.77 247.79,40.09 247.79,42.63 249.37,44.21 257.21,44.21 258.58,45.58 265.54,45.58 v1(265.57,45.55) 265.59,45.58 Q41.3
PCIE_IREF: length 7.1
  TOP w0.305: v2(144.23,102.25) 144.23,102.72 144.41,102.9 144.41,104.23 144.43,104.25 144.43,104.74 144.25,104.91 v1(144.25,105.6) R19.2
  BOTTOM w0.203: U14.B27 144.3,101.24 143.95,101.59 143.95,101.96 v2(144.23,102.25)
PCIE_LAN_WAKE#: length 23.5
  TOP w0.102: U6.21 286.39,47.67 v2(286.36,47.64)
  IN3 w0.114: v2(271.97,44.66) 271.86,44.77 272.42,45.33 273.54,45.33 273.92,44.94 276.39,44.94 277.15,45.71 278.16,45.71 279.69,44.18 281.75,44.18 282.53,44.97 284.56,44.97 286.36,46.77 v2(286.36,47.64)
  BOTTOM w0.102: R439.2 272.64,45.34 v1(273.21,45.91) ; R439.2 270.81,45.34 270.39,44.92 Q41.1 ; R439.2 271.76,44.87 v2(271.97,44.66)
PCIE_MCARD1_DET#: length 5.8
  BOTTOM w0.076: U14.Y3 159.1,90.48 160.26,90.48 160.93,91.15 162.49,91.15 163.28,91.93 163.46,91.93
  BOTTOM w0.102: 163.46,91.93 163.71,91.68 R323.1
PCIE_RCOMP: length 6.8
  TOP w0.305: R20.2 145.55,107.65 v1(145.55,104.89) 145.55,104.51 145.02,103.97 145.02,102.4 v2(144.86,102.25)
  BOTTOM w0.305: v2(144.86,102.25) 144.86,102.07 144.53,101.74 U14.A27
PCIE_RXN2: length 145.5
  TOP w0.114: C329.2 59.92,31.09 59.92,30.62 60.08,30.47 v2(60.42,30.47)
  IN3 w0.102: v2(60.42,30.47) 59.93,30.47 59.72,30.26 59.72,30.01 60.92,28.82 72.3,28.82 74.02,30.54 77.61,30.54 78.42,29.73 80.86,29.73 81.58,29.73 108.26,56.41 108.26,75.97 109.63,77.34 109.63,83.2 112.23,85.79 112.23,87.84 113.67,89.29 114.46,89.29 115.02,89.85 115.02,91.35 116.67,93 117.69,93 118.32,93.63 118.32,94.74 118.87,95.29 120.91,95.29 121.09,95.11 123.83,95.11 124.93,96.2 130.23,96.2 131.17,97.14 135.64,97.14 136,97.5 136,98.13 136.58,98.72 139.85,98.72 140.94,99.81 146.69,99.81 148.01,101.13 149.54,101.13 150.15,100.52 150.15,99.97 151.22,98.89 v2(151.37,98.89)
  BOTTOM w0.089: U14.F15 151.83,98.71 151.7,98.84 151.42,98.84 v2(151.37,98.89)
PCIE_RXN2_C: length 4.9
  TOP w0.114: C329.1 59.98,32.58 59.98,32.83 v1(60.51,33.36) 60.07,33.81 60.07,34.62 59.73,34.95 59.36,34.95 59.09,35.22 59.09,35.37 59.17,35.45 U9.8
PCIE_RXN3: length 197.6
  TOP w0.114: C216.1 283.95,48.88 282.71,48.88 281.62,47.79 281.62,46.52 280.83,45.73 280.83,45.53 v2(281.03,45.33)
  IN1 w0.102: v2(153.31,98.13) 152.68,98.77 152.68,99.94 151.39,101.22 150.89,101.22 150.26,101.84 150.26,103.67 150.63,104.04 155.53,104.04 156.62,102.94 158.07,102.94 160.14,100.88 162.84,100.88 164.6,99.12 169.3,99.12 169.75,98.67 172.65,98.67 174.87,96.44 174.87,93.27 176.21,91.93 176.21,91.55 178.13,89.63 178.13,84.97 178.71,84.39 178.71,83.15 178.07,82.51 178.07,77.7 178.52,77.25 178.52,74.62 178.63,74.51 178.63,69.02 179.54,68.11 179.54,66.1 190.5,55.14 190.5,54.57 193.39,51.67 193.39,48.27 194.22,47.44 194.22,45.17 200.87,38.52 220.89,38.52 221.52,39.15 226.4,39.15 226.83,39.58 229.03,39.58 230.23,38.38 239.63,38.38 240.75,39.5 251.8,39.5 252.19,39.1 260.78,39.1 261.57,39.89 265.02,39.89 265.12,39.99 278.93,39.99 280.68,41.74 280.68,43.98 280.3,44.36 280.3,44.72 280.63,45.05 280.83,45.05 281.03,45.25 v2(281.03,45.33)
  BOTTOM w0.114: U14.G11 153.62,97.82 v2(153.31,98.13)
PCIE_RXN3_C: length 2.8
  TOP w0.114: U6.18 287.08,48.87 287.01,48.93 285.83,48.93 285.81,48.91 285.51,48.91 C216.2
PCIE_RXN4: length 139.4
  IN3 w0.102: v2(152.26,98.82) 152.08,98.99 152.08,99.16 151.84,99.41 151.84,100.32 150.14,102.02 147.63,102.02 146.53,100.93 145.5,100.93 145.3,100.72 144.43,100.72 144.23,100.93 140.87,100.93 139.72,99.78 135.26,99.78 134.22,98.74 129.09,98.74 128.53,98.18 128.53,97.34 128.2,97.01 126.02,97.01 125.64,97.4 124.44,97.4 123.53,96.48 122.13,96.48 121.75,96.1 118.47,96.1 117.99,95.62 115.45,95.62 113.42,93.59 113.42,91.23 111.41,89.22 111.41,86.13 108.82,83.53 108.82,77.7 107.45,76.33 107.45,56.76 81.23,30.54 78.86,30.54 77.51,31.89 74.28,31.89 74,32.17 v2(74,32.56)
  BOTTOM w0.076: 152.75,98.47 152.6,98.47 v2(152.26,98.82)
  BOTTOM w0.089: 152.75,98.47 U14.F13
  BOTTOM w0.114: v2(74,32.56) 74,32.22 74.3,31.91 75.06,31.91 75.19,32.04 75.19,34.33 76.69,35.83 78.34,35.83 78.46,35.95 CN14.43
PCIE_RXP2: length 145.5
  TOP w0.114: v2(59.15,30.47) 59.67,30.99 59.67,31.09 C328.2
  IN3 w0.102: v2(151.37,98.24) 150.94,98.68 150.94,98.89 149.94,99.88 149.94,100.43 149.45,100.93 148.1,100.93 146.78,99.6 141.03,99.6 139.93,98.51 136.67,98.51 136.2,98.05 136.2,97.41 135.73,96.94 131.25,96.94 130.31,96 125.01,96 123.92,94.91 121.01,94.91 120.83,95.08 118.96,95.08 118.52,94.65 118.52,93.55 117.77,92.79 116.75,92.79 115.22,91.27 115.22,89.77 114.55,89.09 113.76,89.09 112.43,87.76 112.43,86.28 112.43,86.28 112.43,85.7 109.84,83.11 109.84,77.25 108.47,75.88 108.47,56.32 81.67,29.53 80.82,29.53 78.33,29.53 77.52,30.34 74.11,30.34 72.38,28.61 60.83,28.61 59.52,29.92 59.52,30.24 59.29,30.47 v2(59.15,30.47)
  BOTTOM w0.089: U14.G15 151.75,97.82 151.37,98.21 v2(151.37,98.24)
PCIE_RXP2_C: length 5
  TOP w0.114: C328.1 59.72,32.69 59.72,32.88 v1(59.24,33.36) 59.81,33.93 59.81,34.51 59.62,34.7 59.26,34.7 58.84,35.12 58.84,35.35 58.77,35.42 U9.7
PCIE_RXP3: length 197.6
  TOP w0.114: C214.1 283.95,49.14 282.6,49.14 281.36,47.89 281.36,46.62 280.58,45.83 280.58,45.2 281.08,44.69 v2(281.11,44.69)
  IN1 w0.102: v2(153.31,98.79) 152.92,99.19 152.92,100.04 151.49,101.46 150.99,101.46 150.5,101.94 150.5,103.57 150.73,103.8 155.43,103.8 156.52,102.7 157.97,102.7 160.04,100.64 162.74,100.64 164.5,98.88 169.19,98.88 169.65,98.42 172.55,98.42 174.63,96.34 174.63,93.17 175.97,91.83 175.97,91.45 177.89,89.53 177.89,84.87 178.47,84.29 178.47,83.25 177.83,82.61 177.83,77.6 178.28,77.15 178.28,74.52 178.39,74.41 178.39,68.92 179.29,68.01 179.29,66 190.25,55.04 190.25,54.47 193.15,51.57 193.15,48.17 193.98,47.34 193.98,45.07 200.77,38.28 220.99,38.28 221.62,38.91 226.5,38.91 226.93,39.34 228.93,39.34 230.13,38.14 239.73,38.14 240.85,39.25 251.7,39.25 252.09,38.86 260.88,38.86 261.67,39.65 265.12,39.65 265.22,39.75 279.03,39.75 280.92,41.64 280.92,44.08 280.54,44.46 280.54,44.62 280.72,44.8 281,44.8 v2(281.11,44.69)
  BOTTOM w0.114: v2(153.31,98.79) 153.63,98.47 U14.F11
PCIE_RXP3_C: length 2.8
  TOP w0.114: C214.2 285.46,49.16 285.65,49.16 285.68,49.19 287.03,49.19 287.11,49.27 U6.17
PCIE_RXP4: length 139.4
  IN3 w0.102: v2(74,31.29) 74.39,31.69 77.43,31.69 78.77,30.34 81.31,30.34 107.65,56.68 107.65,76.25 109.03,77.62 109.03,83.45 111.62,86.04 111.62,89.14 113.62,91.15 113.62,93.5 115.54,95.41 118.08,95.41 118.56,95.9 121.83,95.9 122.22,96.28 123.61,96.28 124.53,97.19 125.55,97.19 125.93,96.81 128.29,96.81 128.74,97.26 128.74,98.1 129.18,98.54 134.31,98.54 135.35,99.58 139.81,99.58 140.95,100.72 144.15,100.72 144.35,100.52 145.38,100.52 145.58,100.72 146.62,100.72 147.71,101.81 150.06,101.81 151.63,100.24 151.63,99.32 151.84,99.12 151.84,98.54 v2(152.23,98.15)
  BOTTOM w0.076: v2(152.23,98.15) 152.39,98.31 152.48,98.31 152.78,98.02 U14.G13
  BOTTOM w0.114: CN14.41 78.47,35.45 78.34,35.58 76.8,35.58 75.45,34.23 75.45,31.94 75.17,31.66 74.37,31.66 v2(74,31.29)
PCIE_TXN2: length 141
  TOP w0.114: C325.2 57.51,32.11 57.51,31.94 v1(58.02,31.43) 57.51,30.92 57.51,30.42 v2(57.77,30.16)
  IN3 w0.102: v2(57.77,30.16) 57.77,30.14 57.51,29.88 57.51,29.61 57.69,29.44 58.06,29.44 58.45,29.83 58.45,31.39 59.03,31.96 61.81,31.96 62.59,31.18 64.14,31.18 67.9,34.94 75.84,34.94 76.34,34.43 79.25,34.43 79.76,34.94 83.24,34.94 105.82,57.53 105.82,77.01 107.2,78.38 107.2,84.23 109.66,86.7 109.66,92.16 115.35,97.85 117.53,97.85 117.7,98.03 119.21,98.03 119.62,98.44 121.17,98.44 122.87,100.14 124.82,100.14 125.13,99.83 126.53,99.83 127.95,101.26 133.91,101.26 134.4,101.75 139.15,101.75 140.15,102.75 141.26,102.75 v2(141.49,102.98)
  BOTTOM w0.076: v2(141.49,102.98) 141.74,102.73 141.83,102.73 142.25,102.31 142.25,101.38 142.1,101.23 141.94,101.23 U14.B31
PCIE_TXN2_C: length 2.9
  TOP w0.114: C325.1 57.51,33.65 57.51,35.34 57.57,35.4 U9.4
PCIE_TXN3: length 206.7
  TOP w0.114: v2(278.29,43.04) 278.14,43.19 278.14,43.37 279.31,44.53 279.31,47.99 281.97,50.66 283.32,50.66 283.55,50.89 284.89,50.89 285.09,51.08 v1(285.87,51.08) 285.87,51.86 285.99,51.98 286.94,51.98 C213.1
  IN1 w0.102: v2(278.29,43.04) 278.11,42.86 278.11,42.44 277.69,42.02 276.68,42.02 275.93,41.26 266.21,41.26 265.69,41.78 263.05,41.78 262.53,41.26 258.13,41.26 257.64,40.77 256.62,40.77 256.24,40.38 255.41,40.38 254.9,40.89 254.46,40.89 253.71,40.14 240.48,40.14 240.16,39.83 230.03,39.83 229.64,40.22 226.37,40.22 226.06,39.9 221.27,39.9 220.56,39.19 218.8,39.19 218.57,39.43 218.23,39.43 217.92,39.13 208.9,39.13 208.62,39.41 200.96,39.41 194.84,45.53 194.84,51.13 191.22,54.75 191.22,55.31 182.43,64.1 182.43,64.95 180.34,67.04 180.34,68.21 179.47,69.08 179.47,77.18 178.68,77.97 178.68,80.47 179.13,80.92 179.13,81.29 178.96,81.45 178.96,82.36 179.32,82.71 179.32,84.65 178.75,85.21 178.75,89.88 176.97,91.67 176.97,93.37 175.88,94.46 175.88,96.39 175.15,97.12 175.15,97.94 173.79,99.3 170.19,99.3 169.48,100.01 164.63,100.01 162.39,102.25 159.64,102.25 157.21,104.67 147.93,104.67 147.6,104.34 146.45,104.34 145.39,103.28 144.06,103.28 v2(143.9,103.11)
  BOTTOM w0.076: v2(143.9,103.11) 143.54,103.47 143.51,103.47 142.97,104 142.48,104 142.2,103.72 142.2,102.82 142.62,102.4 142.62,101.19 142.63,101.17 142.63,100.91 142.65,100.88 142.65,100.71 U14.C29
PCIE_TXN3_C: length 3.6
  TOP w0.114: U6.14 289.2,50.53 289.26,50.6 289.26,51.5 288.56,52.2 288.17,52.2 287.94,51.98 287.94,51.76 C213.2
PCIE_TXN4: length 121.6
  TOP w0.114: v2(78.6,32.04) 78.82,31.81 78.82,29.81 v1(78.32,29.3) 78.82,28.79 78.82,28.51 78.37,28.05 77.72,28.05 C346.1
  IN3 w0.102: v2(78.6,32.04) 78.72,32.04 78.88,31.89 78.88,31.47 79.2,31.15 80.92,31.15 106.84,57.08 106.84,76.59 108.21,77.96 108.21,83.81 110.8,86.4 110.8,91.85 115.41,96.46 117.69,96.46 118.22,96.99 121.58,96.99 122.41,97.82 123.86,97.82 124.53,98.49 125.16,98.49 125.52,98.14 126.41,98.14 127.91,99.63 134.08,99.63 135.17,100.72 139.69,100.72 140.55,101.59 141.9,101.59 142.45,102.14 142.45,102.97 142.58,103.11 142.74,103.11 v2(142.88,102.96)
  BOTTOM w0.076: v2(142.88,102.96) 142.88,102.61 143.04,102.46 143.04,102.04 143.21,101.86 143.21,101.56 142.92,101.27 U14.B29
PCIE_TXN4_C: length 11.4
  TOP w0.114: v2(75.47,28.51) 75.47,28.21 75.67,28 76.12,28 C346.2
  BOTTOM w0.114: v2(75.47,28.51) 75.47,28.38 75.85,28 76.15,28 76.23,28.08 76.23,33.16 77.41,34.33 78.21,34.33 78.34,34.45 CN14.37
PCIE_TXP2: length 141
  TOP w0.114: C324.2 57.26,32.11 57.26,31.94 v1(56.75,31.43) 57.26,30.92 57.26,30.34 v2(57.11,30.19)
  IN3 w0.102: v2(57.11,30.19) 57.31,29.98 57.31,29.53 57.6,29.23 58.15,29.23 58.66,29.74 58.66,31.3 59.11,31.76 61.72,31.76 62.51,30.97 64.23,30.97 67.99,34.73 75.75,34.73 76.26,34.23 79.33,34.23 79.84,34.73 83.32,34.73 106.03,57.44 106.03,76.92 107.4,78.29 107.4,84.15 109.86,86.61 109.86,92.08 115.43,97.65 117.61,97.65 117.79,97.83 119.29,97.83 119.7,98.23 121.25,98.23 122.95,99.94 124.74,99.94 125.04,99.63 126.61,99.63 128.03,101.05 133.99,101.05 134.49,101.55 139.24,101.55 140.24,102.55 141.26,102.55 v2(141.46,102.35)
  BOTTOM w0.076: U14.A31 141.79,101.48 141.89,101.38 142.03,101.38 142.1,101.45 142.1,102.25 141.77,102.58 141.69,102.58 v2(141.46,102.35)
PCIE_TXP2_C: length 2.9
  TOP w0.114: C324.1 57.26,33.65 57.26,35.33 57.17,35.42 U9.3
PCIE_TXP3: length 206.7
  TOP w0.114: C210.1 287.25,52.48 287,52.23 285.88,52.23 285.63,51.98 v1(284.97,51.98) 284.97,51.32 284.79,51.14 283.44,51.14 283.21,50.91 281.87,50.91 279.05,48.1 279.05,44.64 277.88,43.47 277.88,43.32 v2(277.6,43.04)
  IN1 w0.102: v2(277.6,43.04) 277.87,42.77 277.87,42.54 277.59,42.26 276.58,42.26 275.83,41.5 266.31,41.5 265.79,42.02 262.95,42.02 262.43,41.5 258.03,41.5 257.54,41.01 256.52,41.01 256.14,40.63 255.51,40.63 255,41.13 254.36,41.13 253.61,40.38 240.38,40.38 240.06,40.07 230.13,40.07 229.74,40.46 226.27,40.46 225.96,40.14 221.17,40.14 220.46,39.44 218.9,39.44 218.67,39.67 218.13,39.67 217.82,39.37 209,39.37 208.72,39.65 201.06,39.65 195.08,45.63 195.08,51.23 191.46,54.85 191.46,55.41 182.67,64.2 182.67,65.05 180.58,67.14 180.58,68.31 179.71,69.18 179.71,77.28 178.92,78.07 178.92,80.37 179.37,80.82 179.37,81.39 179.21,81.55 179.21,82.26 179.56,82.61 179.56,84.75 179,85.31 179,89.98 177.21,91.77 177.21,93.47 176.12,94.56 176.12,96.49 175.4,97.22 175.4,98.04 173.89,99.54 170.29,99.54 169.58,100.25 164.73,100.25 162.49,102.49 159.74,102.49 157.31,104.91 147.83,104.91 147.5,104.58 146.35,104.58 145.29,103.52 144.13,103.52 v2(143.9,103.75)
  BOTTOM w0.076: v2(143.9,103.75) 143.77,103.62 143.57,103.62 143.04,104.15 142.41,104.15 142.05,103.78 142.05,102.75 142.46,102.34 142.46,101.19 142.36,101.08 U14.B30
PCIE_TXP3_C: length 3.6
  TOP w0.114: C210.2 288.23,52.49 288.63,52.49 289.52,51.6 289.52,50.63 289.6,50.55 U6.13
PCIE_TXP4: length 121.6
  TOP w0.114: C356.1 77.72,27.8 78.47,27.8 79.08,28.4 79.08,28.79 v1(79.59,29.3) 79.08,29.81 79.08,31.84 v2(79.28,32.04)
  IN3 w0.102: v2(79.28,32.04) 79.08,31.84 79.08,31.56 79.28,31.36 80.83,31.36 106.64,57.16 106.64,76.67 108.01,78.04 108.01,83.9 110.6,86.49 110.6,91.93 115.32,96.66 117.6,96.66 118.14,97.19 121.5,97.19 122.33,98.02 123.78,98.02 124.45,98.7 125.25,98.7 125.61,98.34 126.33,98.34 127.82,99.83 133.99,99.83 135.09,100.93 139.6,100.93 140.47,101.79 141.82,101.79 142.25,102.22 142.25,103.06 v2(142.78,103.59)
  BOTTOM w0.076: v2(142.78,103.59) 142.78,103.47 142.44,103.12 142.44,102.84 142.88,102.4 142.88,101.97 142.92,101.94 U14.A29
PCIE_TXP4_C: length 11.4
  TOP w0.114: v2(75.47,27.24) 75.47,27.55 75.67,27.75 76.22,27.75 C356.2
  BOTTOM w0.114: v2(75.47,27.24) 75.47,27.46 75.76,27.74 76.26,27.74 76.49,27.97 76.49,33.05 77.51,34.08 78.21,34.08 78.34,33.95 CN14.35
PCIE_WAKE#_R: length 23.4
  TOP w0.102: v2(163.48,74.37) 163.28,74.16 163.28,71.2 R131.1 163.81,70.73 164.32,71.23 R134.1
  IN3 w0.076: 161.78,81.65 161.78,81.7 160.23,83.25 160.23,84.19 159.95,84.47 159.95,85.48 159.39,86.04 157.94,86.04 157.86,85.96 157.44,85.96 v2(157.05,86.35)
  IN3 w0.114: 161.78,81.65 161.78,79.11 163.33,77.56 163.33,74.52 v2(163.48,74.37)
  BOTTOM w0.102: U14.AJ5 157.05,86.34 v2(157.05,86.35)
PECI_EC: length 12.9
  TOP w0.102: R245.1 227.3,30.14 227.13,29.96 225.97,29.96 225.79,29.78 225.79,29.12 225.61,28.94 225.33,28.94 225.15,29.12 225.15,29.4 224.98,29.58 223.17,29.58 222.99,29.75 222.99,30.11 223.17,30.29 224.98,30.29 225.39,30.71 226.37,30.71 226.55,30.88 226.55,31.05 v2(225.89,31.71)
  BOTTOM w0.102: U23.117 v2(225.89,31.71)
PECI_EC_R: length 197.5
  TOP w0.102: R245.2 228.08,30.02 227.34,29.27 227.34,29.17 v1(225.93,27.76) 225.56,27.39 v2(225.56,26.88)
  IN1 w0.089: v2(113.65,90.16) 113.65,89.37 112.17,87.9 112.17,83.59 110.74,82.16 110.74,78.54 112.15,77.13 112.15,69.15 111.57,68.56 111.57,63.38 111.95,63 111.95,62.67 111.9,62.62 v2(111.9,62.29)
  IN2 w0.114: v2(111.9,62.29) 111.9,59.42 111.06,58.58 111.06,44.41 110.12,43.47 110.12,35.88 v2(112.05,33.95)
  IN3 w0.114: v2(225.56,26.88) 224.7,26.02 210.02,26.02 209.84,26.2 209.84,26.63 209.44,27.02 208.89,27.02 208.62,27.29 199.63,27.29 199.05,27.87 198.71,28.21 198.12,28.8 195.78,28.8 195.11,28.13 191.9,28.13 190.68,29.35 188.96,29.35 187.77,30.54 185.02,30.54 180.41,35.15 156.94,35.15 154.31,32.52 147.84,32.52 146.22,34.14 112.24,34.14 v2(112.05,33.95)
  BOTTOM w0.076: 115.68,93.22 117.83,93.22 117.87,93.25 119.56,93.25 119.99,93.68 119.99,93.95 120.47,94.44 121.2,94.44 121.37,94.27 121.69,94.27 121.99,94.56 U14.N62
  BOTTOM w0.102: v2(113.65,90.16) 113.01,90.79 113.01,91.81 114.42,93.22 115.68,93.22
PEG_RXN0: length 49.4
  TOP w0.114: C28.2 179.83,103.47 v2(179.08,103.47)
  IN3 w0.102: v2(154.19,98.79) 153.77,99.21 153.77,99.82 153.55,100.04 153.55,100.92 153.09,101.37 153.09,102.97 156.06,105.93 157.61,105.93 159.01,107.33 159.01,108.84 161.31,111.14 162.96,111.14 164.92,113.09 172.31,113.09 173.45,114.24 176.85,114.24 180.78,110.31 180.78,104.05 180.3,103.57 179.18,103.57 v2(179.08,103.47)
  BOTTOM w0.114: v2(154.19,98.79) 154.42,98.56 154.46,98.56 154.55,98.47 U14.F10
PEG_RXN0_C: length 12
  TOP w0.114: v2(188.84,100.19) 188.84,100.36 188.45,100.75 188.45,101.69 188.55,101.79 188.55,102.8 188.29,103.06 184.67,103.06 v1(184.16,102.55) 183.65,103.06 182.43,103.06 181.87,103.62 181.22,103.62 C28.1
  BOTTOM w0.114: v2(188.84,100.19) 189.22,100.56 U13.AB9
PEG_RXN1: length 39.4
  TOP w0.114: v2(179.08,106.21) 179.33,105.95 179.69,105.95 180.06,106.33 C24.2
  IN3 w0.102: v2(155.24,98.79) 155.66,99.21 155.66,101.24 156.35,101.92 156.35,103.03 157.29,103.97 158.78,103.97 159.55,104.74 168.3,104.74 170.88,107.32 170.88,108.53 174.38,112.03 176.05,112.03 176.79,111.28 176.79,108.99 178.84,106.95 179.5,106.95 179.74,106.71 179.74,106.24 179.51,106.02 179.27,106.02 v2(179.08,106.21)
  BOTTOM w0.114: U14.F8 155.64,98.72 155.53,98.82 155.26,98.82 v2(155.24,98.79)
PEG_RXN1_C: length 14.5
  TOP w0.114: C24.1 181.22,106.03 182.3,106.03 183.32,105.02 186.06,105.02 v1(186.57,105.52) 187.08,105.02 187.94,105.02 189.88,103.08 189.88,100.92 190.11,100.69 190.22,100.69 v2(190.52,100.98)
  BOTTOM w0.114: U13.AC10 190.5,100.98 v2(190.52,100.98)
PEG_RXN2: length 42.4
  TOP w0.114: v2(179.1,108.39) 179.1,108.32 179.28,108.14 179.69,108.14 180.06,108.51 C14.2
  IN3 w0.102: v2(154.29,97.49) 154.8,98 154.8,99.73 154.95,99.88 154.95,100.87 154.49,101.33 154.49,102.88 156.45,104.84 158.17,104.84 160.16,106.82 160.16,108.55 161.73,110.12 163.38,110.12 165.29,112.03 169.57,112.03 170.39,111.21 171.86,111.21 173.49,112.84 176.38,112.84 178.79,110.44 179,110.44 179.76,109.68 179.76,108.27 179.6,108.11 179.28,108.11 179.1,108.29 v2(179.1,108.39)
  BOTTOM w0.114: U14.H10 154.61,97.17 v2(154.29,97.49)
PEG_RXN2_C: length 15.2
  TOP w0.114: v2(190.5,101.8) 190.91,102.21 190.91,103.83 189.55,105.18 v1(189.55,105.91) 188.82,105.91 188.46,106.27 183.54,106.27 181.4,108.41 181,108.41 C14.1
  BOTTOM w0.114: v2(190.5,101.8) 190.9,101.4 U13.AC11
PEG_RXN3: length 31.6
  TOP w0.114: v2(176.03,111.14) 176.23,110.93 177.4,110.93 v1(177.91,111.44) 178.42,110.93 178.85,110.93 179.44,110.35 179.68,110.35 C7.2
  IN3 w0.102: v2(176.03,111.14) 175.8,110.91 175.34,110.91 168.54,104.11 160.1,104.11 157.86,101.87 157.36,101.87 156.17,100.67 156.17,100.05 156.27,99.95 156.27,99.63 v2(156.07,99.43)
  BOTTOM w0.114: U14.E6 156.59,99.54 156.47,99.66 156.29,99.66 v2(156.07,99.43)
PEG_RXN3_C: length 19.4
  TOP w0.114: v2(191.34,100.96) 191.52,101.14 191.69,101.14 192.44,101.89 192.44,104.66 191.64,105.47 v1(191.64,106.19) 190.91,106.19 189.83,107.28 184.7,107.28 181.5,110.48 181.09,110.48 C7.1
  BOTTOM w0.114: v2(191.34,100.96) 191.74,100.56 U13.AB12
PEG_RXP0: length 49.4
  TOP w0.114: v2(179.08,104.33) 179.08,104.08 179.43,103.72 180.22,103.72 180.3,103.8 180.3,104.01 C27.2
  IN3 w0.102: v2(154.19,99.44) 154.08,99.44 153.97,99.55 153.97,99.91 153.75,100.12 153.75,101 153.3,101.46 153.3,102.88 156.14,105.73 157.69,105.73 159.22,107.25 159.22,108.76 161.39,110.93 163.04,110.93 165,112.89 172.39,112.89 173.53,114.03 176.77,114.03 180.58,110.22 180.58,104.13 180.21,103.77 179.38,103.77 179.08,104.08 v2(179.08,104.33)
  BOTTOM w0.114: v2(154.19,99.44) 154.27,99.53 154.52,99.53 154.68,99.36 U14.E10
PEG_RXP0_C: length 12
  TOP w0.114: v2(188.87,100.97) 188.7,101.13 188.7,101.59 188.81,101.69 188.81,102.91 188.4,103.31 184.67,103.31 v1(184.16,103.82) 183.65,103.31 182.53,103.31 181.97,103.87 181.22,103.87 C27.1
  BOTTOM w0.114: U13.AC9 189.47,101.21 189.47,101.08 189.36,100.97 v2(188.87,100.97)
PEG_RXP1: length 39.3
  TOP w0.114: C25.2 179.76,105.7 179.23,105.7 v2(179.1,105.57)
  IN3 w0.102: v2(179.1,105.57) 179.34,105.81 179.6,105.81 179.94,106.16 179.94,106.79 179.59,107.15 178.93,107.15 177,109.08 177,111.37 176.13,112.23 174.3,112.23 170.68,108.61 170.68,107.4 168.22,104.94 159.46,104.94 158.7,104.18 157.2,104.18 156.14,103.12 156.14,102.01 155.46,101.32 155.46,99.59 155.33,99.46 155.25,99.46 v2(155.24,99.44)
  BOTTOM w0.114: U14.E8 155.56,99.12 v2(155.24,99.44)
PEG_RXP1_C: length 14.5
  TOP w0.114: C25.1 181.22,105.78 182.2,105.78 183.21,104.76 186.06,104.76 v1(186.57,104.25) 187.08,104.76 187.84,104.76 189.62,102.98 189.62,100.81 190,100.43 190.22,100.43 v2(190.52,100.14)
  BOTTOM w0.114: U13.AB10 190.5,100.14 v2(190.52,100.14)
PEG_RXP2: length 42.4
  TOP w0.114: C20.2 179.73,107.89 179.26,107.89 v2(179.1,107.73)
  IN3 w0.102: v2(154.29,98.14) 154.59,98.45 154.59,99.82 154.75,99.97 154.75,100.79 154.29,101.25 154.29,102.97 156.36,105.04 158.09,105.04 159.95,106.9 159.95,108.63 161.65,110.32 163.3,110.32 165.21,112.23 169.66,112.23 170.48,111.42 171.78,111.42 173.41,113.04 176.47,113.04 178.87,110.64 179.09,110.64 179.97,109.76 179.97,108.19 179.69,107.91 179.28,107.91 v2(179.1,107.73)
  BOTTOM w0.114: U14.G10 154.61,97.82 v2(154.29,98.14)
PEG_RXP2_C: length 15.2
  TOP w0.114: C20.1 180.5,107.89 180.5,108.04 180.62,108.16 181.29,108.16 183.43,106.02 188.36,106.02 188.65,105.72 v1(188.65,105.02) 189.36,105.02 190.66,103.72 190.66,102.76 v2(190.5,102.6)
  BOTTOM w0.114: v2(190.5,102.6) 190.38,102.48 190.38,102.37 190.51,102.25 190.87,102.25 U13.AD11
PEG_RXP3: length 31.5
  TOP w0.114: C10.2 179.68,110.1 179.33,110.1 178.75,110.68 178.42,110.68 v1(177.91,110.17) 177.4,110.68 176.23,110.68 v2(176.03,110.48)
  IN3 w0.102: v2(176.03,110.48) 175.8,110.7 175.42,110.7 168.62,103.9 160.19,103.9 157.95,101.66 157.45,101.66 156.37,100.59 156.37,100.14 156.47,100.04 156.47,99.21 v2(156.07,98.8)
  BOTTOM w0.114: v2(156.07,98.8) 156.4,98.47 U14.F6
PEG_RXP3_C: length 19.4
  TOP w0.114: C10.1 180.84,110.03 181.03,110.22 181.39,110.22 184.59,107.02 189.72,107.02 190.74,106.01 v1(190.74,105.29) 191.45,105.29 192.18,104.56 192.18,101.99 191.59,101.4 191.46,101.4 191.34,101.52 v2(191.34,101.8)
  BOTTOM w0.114: v2(191.34,101.8) 191.22,101.68 191.22,101.58 191.4,101.4 U13.AC12
PEG_TXN0: length 45.7
  IN3 w0.102: v2(146.21,106.56) 145.98,106.34 145.83,106.34 145.42,105.93 145.42,105.36 145.88,104.91 145.88,104.12 146.54,103.46 146.54,102.73 v2(146.97,102.3)
  BOTTOM w0.076: v2(146.97,102.3) 147.1,102.3 147.21,102.18 147.21,101.89 147.25,101.86 147.25,101.62 147.2,101.57 147.2,101.53 147.06,101.38 U14.C23
  BOTTOM w0.114: v2(146.21,106.56) 146.36,106.41 146.72,106.41 146.87,106.56 146.87,108.63 147.89,109.64 147.89,110.71 148.47,111.29 150.59,111.29 151.64,112.33 157.54,112.33 158.17,111.7 163.3,111.7 163.89,112.28 169.05,112.28 169.96,111.37 171.41,111.37 171.79,110.98 v1(172.47,110.98) 172.47,110.3 175.09,107.68 176.87,107.68 177.01,107.83 C413.2
PEG_TXN0_C: length 11.6
  BOTTOM w0.114: C413.1 178.02,107.96 178.19,107.96 179,107.15 180.45,107.15 180.63,106.97 181.65,105.95 186.83,105.95 187.31,105.47 187.31,104.89 U13.AG7
PEG_TXN1: length 46.8
  IN3 w0.102: v2(146.01,102.68) 145.83,102.86 145.36,102.86 144.92,103.31 144.92,104.43 144.13,105.22 144.13,106.82 144.41,107.1 144.71,107.1 144.86,107.25 v2(144.86,107.33)
  BOTTOM w0.076: U14.B23 146.69,101.26 146.41,101.55 146.41,102.5 146.23,102.68 v2(146.01,102.68)
  BOTTOM w0.114: C408.2 176.63,109.84 174.94,109.84 174.68,110.1 v1(174.68,110.83) 173.95,110.83 171.61,113.17 160.01,113.17 159.64,112.79 158.51,112.79 157.75,113.55 151.54,113.55 150.17,112.18 148.09,112.18 146.74,110.83 146.74,109.82 145.4,108.47 145.4,107.33 145.22,107.15 145.04,107.15 v2(144.86,107.33)
PEG_TXN1_C: length 15.8
  BOTTOM w0.114: U13.AE7 187.6,103.27 188.02,103.69 188.02,104 188.27,104.25 188.27,105.55 187.29,106.54 183.25,106.54 181.72,108.07 180.5,109.28 180.32,109.28 v1(179.79,109.82) 179.28,109.31 178.77,109.31 178.24,109.84 177.99,109.84 177.79,110.04 C408.1
PEG_TXN2: length 48.9
  IN3 w0.102: v2(145.65,110.27) 145.88,110.04 145.88,109.36 149.46,105.78 149.46,103.26 149.26,103.06 149.06,103.06 148.8,103.31 v2(148.8,103.34)
  BOTTOM w0.076: U14.B21 147.99,100.66 147.99,100.77 147.82,100.93 147.82,101.26 148.18,101.61 148.18,101.97 148.24,102.04 148.24,102.77 148.46,102.98 148.52,102.98 148.8,103.27 v2(148.8,103.34)
  BOTTOM w0.114: v2(145.65,110.27) 145.87,110.49 145.87,112.07 146.85,113.05 149.81,113.05 151.43,114.68 163.97,114.68 164.61,114.04 169.84,114.04 170.16,114.36 172.86,114.36 173.44,113.78 v1(174.15,113.78) 174.15,113.07 175.34,111.87 176.63,111.87 C404.2
PEG_TXN2_C: length 17
  BOTTOM w0.114: C404.1 177.71,112.17 177.71,111.85 177.83,111.72 178.24,111.72 178.52,112 179.05,112 179.27,111.78 v1(179.98,111.78) 179.98,111.05 183.88,107.15 187.69,107.15 188.86,105.98 188.86,104.43 189.28,104.01 U13.AF9
PEG_TXN3: length 48.5
  IN3 w0.102: v2(147.4,103.41) 147.56,103.57 147.56,106.53 146.15,107.94 145.51,107.94 143.92,109.53 143.92,109.84 v2(143.54,110.22)
  BOTTOM w0.076: U14.B22 147.58,101.16 147.58,102.2 147.81,102.43 147.81,102.63 147.58,102.86 147.58,103.24 v2(147.4,103.41)
  BOTTOM w0.114: v2(143.54,110.22) 143.9,110.58 143.9,111.34 146.49,113.93 149.43,113.93 151.06,115.56 164.41,115.56 164.66,115.3 173.16,115.3 173.71,114.74 174.94,114.74 175.78,113.91 176.63,113.91 C402.2
PEG_TXN3_C: length 18.1
  BOTTOM w0.114: C402.1 178.07,114.01 178.98,114.01 179.17,113.81 v1(179.9,113.81) 179.9,113.16 181.36,111.7 181.36,110.93 184.51,107.78 188.45,107.78 189.81,106.43 189.81,104.71 189.92,104.6 U13.AG10
PEG_TXP0: length 45.7
  IN3 w0.102: v2(146.97,102.96) 146.74,103.19 146.74,103.54 146.08,104.2 146.08,104.99 145.63,105.45 145.63,105.85 145.91,106.13 146.01,106.13 v2(146.21,105.93)
  BOTTOM w0.076: v2(146.97,102.96) 147.37,102.56 147.37,101.96 147.4,101.92 147.4,101.55 147.35,101.51 147.35,101.46 147.21,101.32 147.21,100.9 147.46,100.65 U14.C22
  BOTTOM w0.114: v2(146.21,105.93) 146.44,106.16 146.82,106.16 147.13,106.46 147.13,108.52 148.14,109.54 148.14,110.6 148.57,111.03 150.7,111.03 151.74,112.08 157.44,112.08 158.07,111.44 163.41,111.44 163.99,112.03 168.94,112.03 169.85,111.11 171.3,111.11 171.58,110.84 v1(171.58,110.09) 172.33,110.09 174.99,107.43 176.76,107.43 C416.2
PEG_TXP0_C: length 11.6
  BOTTOM w0.114: C416.1 177.79,107.61 177.88,107.71 178.08,107.71 178.9,106.89 180.35,106.89 181.54,105.7 186.72,105.7 187.05,105.37 187.05,104.86 U13.AG6
PEG_TXP1: length 46.8
  IN3 w0.102: v2(144.86,106.67) 144.86,106.74 144.71,106.89 144.49,106.89 144.33,106.73 144.33,105.3 145.12,104.52 145.12,103.39 145.45,103.06 145.75,103.06 v2(146.01,103.31)
  BOTTOM w0.076: U14.A23 146.96,101.52 146.9,101.46 146.73,101.46 146.58,101.61 146.58,102.67 146.01,103.24 v2(146.01,103.31)
  BOTTOM w0.114: v2(144.86,106.67) 144.86,106.68 145.06,106.87 145.32,106.87 145.65,107.2 145.65,108.36 147,109.71 147,110.72 148.2,111.92 150.27,111.92 151.65,113.3 157.64,113.3 158.4,112.54 159.74,112.54 160.12,112.91 171.51,112.91 173.79,110.63 v1(173.79,109.93) 174.49,109.93 174.83,109.59 176.63,109.59 C410.2
PEG_TXP1_C: length 15.8
  BOTTOM w0.114: C410.1 177.79,109.44 177.93,109.59 178.14,109.59 178.67,109.05 179.28,109.05 v1(179.79,108.55) 180.27,109.03 180.4,109.03 183.14,106.29 187.18,106.29 188.02,105.45 188.02,104.35 187.87,104.2 187.43,104.2 187.16,103.92 187.16,103.62 187.26,103.52 187.49,103.52 187.6,103.63 U13.AF7
PEG_TXP2: length 49
  IN3 w0.102: v2(148.8,102.71) 148.95,102.86 149.34,102.86 149.67,103.18 149.67,105.86 146.08,109.44 146.08,110.04 v2(146.31,110.27)
  BOTTOM w0.076: U14.C21 148.25,100.72 147.98,101 147.98,101.2 148.33,101.55 148.33,101.91 148.4,101.97 148.4,102.7 148.52,102.83 148.69,102.83 v2(148.8,102.71)
  BOTTOM w0.114: C405.2 176.63,111.62 175.24,111.62 173.98,112.88 v1(173.25,112.88) 173.25,113.61 172.75,114.11 170.26,114.11 169.95,113.79 164.5,113.79 163.87,114.42 151.53,114.42 149.91,112.8 146.96,112.8 146.12,111.96 146.12,110.46 v2(146.31,110.27)
PEG_TXP2_C: length 17
  BOTTOM w0.114: C405.1 178.02,111.47 178.35,111.47 178.62,111.75 178.95,111.75 179.08,111.62 v1(179.08,110.88) 179.79,110.88 182.16,108.51 183.77,106.89 187.58,106.89 188.6,105.87 188.6,104.33 188.91,104.02 188.91,103.64 189.28,103.27 U13.AE9
PEG_TXP3: length 48.4
  IN3 w0.102: v2(144.81,110.22) 144.48,110.22 144.13,109.87 144.13,109.61 145.6,108.14 146.23,108.14 147.76,106.62 147.76,103.64 147.96,103.44 v2(148.14,103.44)
  BOTTOM w0.076: v2(148.14,103.44) 147.99,103.44 147.73,103.19 147.73,102.92 147.96,102.69 147.96,102.37 147.73,102.13 147.73,101.88 U14.A21
  BOTTOM w0.114: C403.2 176.63,113.65 175.67,113.65 174.84,114.49 173.61,114.49 173.05,115.05 164.56,115.05 164.3,115.3 151.16,115.3 149.54,113.68 146.59,113.68 144.15,111.24 144.15,110.63 144.56,110.22 v2(144.81,110.22)
PEG_TXP3_C: length 18.2
  BOTTOM w0.114: U13.AG9 189.44,104.6 189.55,104.71 189.55,106.32 188.35,107.53 184.4,107.53 181.11,110.82 181.11,111.59 179.79,112.91 v1(179,112.91) 179,113.62 178.87,113.75 177.83,113.75 177.71,113.63 177.71,113.36 C403.1
PEGX_RST#: length 39.7
  TOP w0.102: v1(182.66,74.74) 182.66,75.4 v2(182.84,75.58) ; v2(182.15,100.42) 181.85,100.72 180.09,100.72 179.94,100.87 R30.2 ; U1.4 178.89,93.7 179.4,94.21 R49.2 R50.2 181.45,94.21 v2(181.57,94.09)
  IN1 w0.089: v2(182.84,75.58) 182.84,79.46 183.52,80.15 183.52,80.71 184.32,81.5 184.32,83.43 184.06,83.69 184.06,86.61 184.41,86.97 184.41,89.29 182.38,91.32 182.38,93.28 v2(181.57,94.09)
  BOTTOM w0.102: v2(181.57,94.09) 181.06,94.6 181.06,100.19 181.29,100.42 v2(182.15,100.42) ; v2(182.84,75.58) 183.59,74.83 184.76,74.83 185.71,73.87 Q39.2
PEQ: length 5.2
  TOP w0.102: R509.1 R512.1 248.68,33.78 249.39,34.48 v1(249.72,34.48) 249.72,33.92 250.52,33.11 U25.4
PEX_CLKREQ#: length 33.5
  TOP w0.102: v2(180.75,78.24) 180.87,78.13 181.11,77.88 Q8.2 181.82,77.18 182.35,76.64 v1(182.53,76.64) ; R35.1 v2(181.47,99.94)
  IN3 w0.114: v2(181.47,99.94) 182.37,99.03 182.37,92.64 181.47,91.73 181.47,87.53 180.46,86.52 180.46,84.81 180.55,84.72 180.55,81.38 179.9,80.73 179.9,78.55 180.2,78.24 v2(180.75,78.24)
  BOTTOM w0.127: U13.AC6 186.35,100.95 185.77,100.95 185.49,100.67 185.49,100.34 185.24,100.08 182.53,100.08 182.38,99.94 v2(181.47,99.94)
PEX_PLLVDD: length 1.2
  BOTTOM w0.305: U13.AA15 194.21,99.76 v2(193.81,100.16) ; U13.AA14 193.38,99.76 v2(193,100.14)
  vias: v1(194.93,108.47) v2(192.85,106.44) v2(193.51,106.44)
PEX_TERMP: length 6.9
  BOTTOM w0.102: v1(202.5,109.94) 202.78,109.66 202.78,108.37 202.49,108.08 R285.2 202.24,105.68 202.07,105.5 202.07,104.23
  BOTTOM w0.381: U13.AF25 202.07,104.23
PEX_TSTCLK: length 8.2
  BOTTOM w0.102: U13.AF22 200.03,103.8 200.35,104.12 200.35,105.83 198.49,107.68 v1(196.48,107.68) 196.25,107.91 R286.2
PEX_TSTCLK#: length 10.5
  BOTTOM w0.102: U13.AE22 199.79,103 199.53,103.26 199.53,103.64 199.54,103.66 199.54,105.51 198.18,106.87 194.93,106.87 194.46,107.34 R286.1 194.41,107.96 v1(193.28,107.96)
PGOOD: length 6.5
  TOP w0.102: v1(138.47,29.78) 138.5,29.8 138.5,30.25 138.31,30.44 136.66,30.44 136.39,30.17 PR89.2
  TOP w0.279: PU4.23 134.29,28.84 134.61,29.16 135.68,29.16 135.92,29.39 136.22,29.39 136.39,29.56 PR89.2
PIRQ_GPIO77: length 12.7
  TOP w0.102: R40.1 165.74,97.52 v1(164.77,96.54) 163.84,95.62 163.84,95.03 162.83,94.02 160.29,94.02 159.65,93.38 159.65,92.54 159.34,92.24 158.32,92.24 157.97,92.59 157.46,92.59 157.05,93 v2(157.05,93.02)
  BOTTOM w0.076: 156.93,92.92 157.05,93.04 v2(157.05,93.02)
  BOTTOM w0.102: 156.93,92.92 156.86,92.84 U14.U6
PIRQ_GPIO78: length 20.2
  BOTTOM w0.076: 162.43,94.14 161.54,94.14 161.37,93.97 160.76,93.97 160.26,93.48 159,93.48 158.96,93.44 158.48,93.44 U14.P4
  BOTTOM w0.102: TP67.1 171.74,100.52 171.53,100.32 171.53,96.42 170.89,95.77 170.87,95.77 170.85,95.75 170.05,95.75 170.01,95.71 170,95.71 169.63,95.34 169.63,95.33 169.6,95.31 169.6,94.42 169.32,94.14 167.95,94.14 167.39,94.7 166.12,94.7 165.92,94.5 162.79,94.5 162.43,94.14
PIRQ_GPIO79: length 14.3
  TOP w0.102: TP68.1 168.94,92.24 168.56,92.62 168.46,92.62 v2(168.44,92.64)
  IN1 w0.089: v2(157.74,93.97) 157.74,94.22 158.15,94.63 159.6,94.63 159.85,94.37 162.59,94.37 163.28,93.69 164.17,93.69 164.68,93.18 166.66,93.18 166.94,92.9 168.18,92.9 v2(168.44,92.64)
  BOTTOM w0.076: U14.N4 158.19,94.42 v2(157.74,93.97)
  BOTTOM w0.102: v1(169.17,92.57) 168.51,92.57 v2(168.44,92.64)
PIRQ_GPIO80: length 9.2
  BOTTOM w0.076: 161.65,94.65 161.34,94.65 161.16,94.47 160.51,94.47 160.26,94.23 160.02,94.23 159.73,94.52 U14.N2
  BOTTOM w0.102: v1(165.46,96.4) 165.46,96.46 165.71,96.7 R308.1 165.06,97.41 164.91,97.27 163.48,97.27 162.47,96.25 162.47,95.84 161.98,95.35 161.98,94.98 161.65,94.65
PLTRST#: length 457.9
  TOP w0.102: R229.2 54.86,32.74 v2(55.25,33.13) ; R135.2 176.78,74.3 v2(176.87,74.2) 177.27,74.2 177.55,73.93 177.55,72.35 177.27,72.07 v1(177.27,72.05) ; U1.2 175.95,94.35 175.62,94.68 v2(175.4,94.68)
  IN1 w0.089: v2(55.25,33.13) 55.28,33.13 56.55,31.86 61.07,31.86 62.64,30.29 v2(62.64,30.03)
  IN3 w0.114: v2(55.25,33.13) 54.85,32.73 54.85,29.99 57.42,27.42 63.2,27.42 63.84,26.78 74.56,26.78 75.07,26.28 76.68,26.28 76.94,26.54 78.85,26.54 80.03,27.72 82.61,27.72 85.35,30.47 89.82,30.47 91.18,31.82 101.85,31.82 107.13,37.11 107.13,43.98 109.52,46.36 109.52,48.31 114.64,53.43 114.64,60.56 114.46,60.74 114.46,67.06 115.41,68.01 115.41,72.42 120.42,77.43 120.42,77.43 120.62,77.63 120.62,82.56 120.9,82.84 121.37,82.84 121.8,83.27 121.8,84.39 122.73,85.32 124.65,85.32 127.25,87.92 130.34,87.92 133.78,91.36 143.88,91.36 145.04,90.19 146.53,90.19 147.35,89.37 147.35,88.94 147.69,88.61 148.98,88.61 149.27,88.32 152.29,88.32 152.66,87.95 154.57,87.95 155.66,86.85 155.96,86.85 v2(156.41,87.3) 156.83,86.88 157.97,86.88 158.53,87.44 161.49,87.44 161.9,87.85 164.88,87.85 166.92,89.9 166.92,91.86 168.17,93.11 168.85,93.11 170.31,94.57 173.18,94.57 173.29,94.68 v2(175.4,94.68) 175.62,94.68 175.93,94.36 175.93,92.98 176.19,92.72 176.19,89.39 176.03,89.23 176.03,82.84 176.47,82.39 176.47,78.23 176.47,77.28 176.39,77.19 176.39,74.68 v2(176.87,74.2) 175.41,72.74 175.41,72.74 175.4,72.74 174.1,72.74 170.11,68.75 170.11,62.63 171.59,61.16 171.85,60.9 171.85,59.76 169.91,57.82 169.91,54.12 176.24,47.79 178.33,47.79 178.97,47.16 179.47,46.65 182.38,46.65 182.94,46.65 188.79,40.8 190.63,40.8 192.24,39.19 192.25,39.19 194.29,39.19 194.33,39.15 198.09,35.39 200.43,35.39 200.78,35.04 209.48,35.04 210.76,33.76 219.03,33.76 219.54,34.26 225.47,34.26 225.99,34.78 230.51,34.78 230.67,34.94 235.03,34.94 235.48,34.49 240.56,34.49 243.2,37.13 261.01,37.13 261.79,37.92 265.79,37.92 267.3,36.41 268.25,36.41 268.51,36.14 274.35,36.14 275.69,34.8 277.42,34.8 278.25,33.97 281.08,33.97 283.27,31.79 284.29,31.79 284.97,31.1 284.97,30.31 287.18,28.1 287.59,28.1 289.82,25.87 293.61,25.87 295.61,27.88 296.78,27.88 297.09,27.57 300.82,27.57 301.81,26.58 306.84,26.58 310.14,29.88 310.14,34.48 307.98,36.64 306.33,36.64 300.97,42 295.69,42 294.98,41.29 292.76,41.29 292.29,41.77 292.29,44.61 290.79,46.11 288.86,46.11 288.12,46.85 288.12,49.54 287.74,49.92 287.03,49.92 v2(286.75,49.64)
  BOTTOM w0.102: R433.1 286.49,49.38 v2(286.75,49.64) ; v2(62.64,30.03) 62.64,31.02 64.5,32.88 67.04,32.88 70.35,36.19 70.35,37.58 70.98,38.2 CN14.52 ; v2(156.41,87.3) 156.38,87.28 156.38,87.01 U14.AG7 ; v2(176.87,74.2) 176.63,74.2 176.07,73.65 U15.2 173.25,73.65 173.19,73.58 173.19,73.16 173.35,73 U15.1
PM_BATLOW#: length 12.7
  TOP w0.102: v2(158.49,83.65) 159,83.15 159.23,83.15 159.95,82.42 159.95,79.46 160.51,78.9 160.51,77.76 159.9,77.15 v1(159.9,75.35) 159.9,73.34 159.75,73.19 R122.1
  BOTTOM w0.102: U14.AN4 158.19,83.35 v2(158.49,83.65)
PM_TEST_RST_N: length 9.2
  TOP w0.102: TP49.1 166.7,88.17 161.17,88.17 v2(160.64,88.71)
  BOTTOM w0.076: U14.AC4 158.43,89.23 158.72,88.94 159.14,88.94 159.27,88.82 160.53,88.82 v2(160.64,88.71)
PORTD_FS: length 37.1
  TOP w0.102: v2(272.34,41.92) 272.34,41.56 272.08,41.3 U7.24 ; v2(289.38,36.73) 289.38,36.99 290.47,38.09 291.86,38.09 292.84,39.06 294.62,39.06 294.83,39.28 296.07,39.28 296.68,39.89 297.33,39.89 297.74,39.48 299.35,39.48 299.73,39.1 302.87,39.1 303.56,38.41 U10.48
  IN3 w0.114: v2(272.34,41.92) 272.95,41.31 276.41,41.31 276.46,41.25 277.15,41.25 278.15,40.26 281.18,40.26 281.67,39.77 283.62,39.77 285.82,37.57 288.54,37.57 v2(289.38,36.73)
POWER_SW_IN0#: length 44.7
  TOP w0.102: G1.1 200.24,28.21 201.35,28.21 201.72,28.57 C349.1 203,28.57 v1(203.41,28.15) 203.64,27.93 v2(203.64,26.86) ; v2(213.32,22.62) 212.25,21.55 212.25,19.85 211.64,19.85 209.96,18.17 194.93,18.17 v2(194.06,19.04) 193.84,18.81 D7.3
  BOTTOM w0.102: CN16.29 204.32,27.13 204.05,26.86 v2(203.64,26.86) 203.64,26.3 205.98,23.96 211.97,23.96 v2(213.32,22.62) ; G2.2 194.81,17.88 194.06,18.63 v2(194.06,19.04)
PRE: length 5.4
  TOP w0.102: v1(316.64,82.54) 315.17,82.54 314.68,82.04 ; U2.16 313.24,82.86 313.52,83.15 314.58,83.15 R83.1 314.68,82.04 ; R87.2 314.68,82.04
PROC_DETECT#: length 12.8
  TOP w0.102: TP38.1 121.34,110.65 121.34,103.87 120.79,103.31 v2(120.79,101.84)
  BOTTOM w0.076: v2(120.79,101.84) 121.09,101.54 121.09,101 121.34,100.75 121.65,100.75 121.72,100.68 122.3,100.68 122.59,100.4 122.59,100.16 U14.D61
PROC_OPI_COMP: length 9
  BOTTOM w0.076: v1(147.62,72.88) R402.1
  BOTTOM w0.305: R402.1 148.82,72.88 149.26,73.32 149.94,73.32 151.24,74.61 151.24,78.83 U14.AY15
PS8330_RST#: length 5.6
  TOP w0.102: U25.35 259.53,34.11 259.88,34.45 R513.2 261.09,35.04 260.87,35.26 C536.1 260.29,36.22 v1(259.79,36.22)
PS_FB_CLAMP: length 126.9
  TOP w0.102: R71.2 180.7,86.9 v2(182.24,88.44) ; PD1.1 248.27,49.01 244.32,49.01 244.15,48.84 244.15,47.43 244.24,47.34 244.24,46.2 243.67,45.63 239.35,45.63 237.67,43.95 232.01,43.95 230.66,45.3 224.85,45.3 v1(223.73,44.18) 223.38,43.83 200.28,43.83 196.35,47.76 196.35,49.35 v2(196.49,49.49) 196.58,49.58 196.58,56.09 193.63,59.04 v2(189.92,59.04)
  IN3 w0.114: v2(189.92,59.04) 189.59,59.37 183.02,59.37 178.57,63.82 178.57,68.9 180.53,70.86 180.53,77.28 181.18,77.93 181.18,78.35 181.18,81.37 180.86,81.7 180.86,85.11 181.69,85.94 181.69,88 182.14,88.44 v2(182.24,88.44)
  BOTTOM w0.102: v2(196.49,49.49) 195.78,50.2 194.31,50.2 194.14,50.03 R434.2 ; R335.1 181.9,88.76 182.21,88.44 v2(182.24,88.44) 183.76,88.44 183.9,88.3 183.9,87.69 U13.F3
PS_FB_CLAMP_R: length 33.2
  BOTTOM w0.102: R434.1 193.25,48.78 193.63,48.4 198.08,48.4 198.51,47.97 198.51,45.68 v1(198.98,45.21) 200.54,43.65 200.99,43.65 201.56,43.65 201.56,43.65 205.57,43.65 207.15,42.07 207.15,41.23 209.69,38.69 217.36,38.69 217.45,38.59 218.8,38.59 218.9,38.69 U23.18
PWR_LED#_R: length 2.9
  TOP w0.102: R1.1 155.1,125.56 v1(155.1,126.07) 154.47,126.7 LED1.2
R_SPK+: length 11.3
  IN1 w1.016: 294.27,38.42 297.01,41.16 300.77,41.16 301.23,40.7 303.47,40.7
  BOTTOM w0.102: v1(294.14,37.2) v2(293.58,37.76)
  vias: v2(293.02,38.04) v2(305.62,40.12) v2(305.6,39.48)
R_SPK+_R: length 12.9
  BOTTOM w0.787: CN10.6 305.03,38.58 304.81,38.8 303.93,38.8
  BOTTOM w1.016: 295.31,37.78 297.52,37.78 297.85,38.11 298.86,38.11 v1(300.19,39.43) 301.13,39.43 301.63,38.92 303.8,38.92 303.93,38.8
R_SPK-: length 17.2
  IN1 w1.016: 291.91,37.2 291.91,38.7 293.78,40.58 294.27,40.58 296.38,42.68 304.76,42.68 305.57,41.87
  vias: v1(291.6,35.88) v2(292.08,36.94) v2(292.72,36.94) v2(306.33,39.56) v2(306.36,40.22)
R_SPK-_R: length 13.1
  BOTTOM w0.787: 303.23,37.6 303.28,37.65 304.58,37.65 304.91,37.33 CN10.5
  BOTTOM w1.016: 303.23,37.6 301.23,37.6 299.92,36.3 v1(299.87,36.3) 298.74,35.17 295.28,35.17
REG_OUT:
  vias: v1(285.83,45.81) v2(286.75,45.96) v2(286.75,45.33) v2(287.41,45.3) v2(287.49,45.93)
REGN_LDO: length 32
  TOP w0.102: PC48.1 40.04,31.13 v1(40.04,32.02)
  TOP w0.254: v2(48.27,23.25) 48.27,23.38 PR96.1 48.91,22.77 PR104.1
  TOP w0.279: v2(45.12,29.85) 45.67,29.29 PU3.16
  TOP w0.508: 41.26,30.19 41.26,31.51 41.87,32.12 44,32.12 44.89,31.23 44.89,30.08 v2(45.12,29.85) ; 41.26,30.19 PD2.2 ; 41.26,30.19 40.5,30.95 PC48.1
  BOTTOM w0.254: PR115.1 43.92,19.8 43.42,20.31 43.42,22.21 44.43,23.23 44.94,23.23 45.51,23.8 46.08,23.23 48.24,23.23 v2(48.27,23.25)
  BOTTOM w0.508: v2(45.12,29.85) 46.21,28.76 46.21,27.04 45.51,26.34 45.51,23.8
REM_DIODE1_N: length 53.3
  TOP w0.254: Q7.1 137.92,92.23 C114.2 137.22,91.53 v1(135.19,91.53) 132.19,91.53 131.02,90.36 131.02,87.81 128.95,85.74 122.23,85.74 121.67,85.18 119.52,85.18 117.97,86.73 113.82,86.73 108.95,81.86 108.95,75.55 109.66,74.84 112.07,74.84 112.5,74.41 113.95,74.41 114.13,74.22 114.13,73.88 C191.2 114.17,73.62 114.17,72.85 114.08,72.76 U3.3
REM_DIODE1_P: length 52.8
  TOP w0.254: Q7.2 140.14,91.57 Q7.3 138.16,90.91 137.41,90.91 C114.1 137.37,90.92 137.27,91.02 136.39,91.02 136.26,90.89 v1(133.04,90.89) 132.27,90.89 131.53,90.15 131.53,87.6 129.16,85.23 122.44,85.23 121.88,84.67 119.3,84.67 117.76,86.22 114.03,86.22 109.46,81.65 109.46,75.76 109.87,75.35 112.28,75.35 112.72,74.92 114.16,74.92 114.64,74.43 114.64,73.93 C191.1 114.68,73.65 114.68,72.82 114.74,72.76 U3.2
REXT: length 4
  TOP w0.102: U25.7 250.04,31.61 v1(249.72,31.94) 249.72,31.43 248.74,30.46 R503.1
ROM_CS: length 4.8
  TOP w0.114: TP12.1 190.79,82.33 190.79,84.65 v2(191.34,85.19)
  BOTTOM w0.102: U13.D12 191.75,85.6 v2(191.34,85.19)
ROM_SCLK: length 7.6
  TOP w0.102: v2(191.32,84.39) v1(191.32,83.7) 191.32,83.43 192.34,82.41 192.34,81.06 191.66,80.39 R100.1 191.66,80.06 191.93,79.79 192.79,79.79 193.03,80.03 R101.2
  BOTTOM w0.102: v2(191.32,84.39) 191.74,84.81 191.76,84.81 U13.C12
ROM_SI: length 15.7
  BOTTOM w0.102: R413.1 R401.2 189.92,73.51 190.08,73.67 190.08,75.22 v1(190.27,75.42) 190.61,75.75 192.29,75.75 192.72,76.19 192.72,78.73 193.4,79.41 193.4,81.06 191.76,82.7 191.76,82.71 191.42,83.06 191.42,83.34 191.44,83.37 191.44,83.68 U13.B12
ROM_SO: length 13.7
  BOTTOM w0.102: U13.A12 191.97,82.99 191.97,82.79 193.61,81.15 193.61,79.26 193,78.65 193,75.37 192.59,74.97 v1(192.59,74.36) 192,73.77 191.36,73.77 191.1,73.51 R400.2 R412.1
RREF: length 5.6
  TOP w0.102: R219.2 61.82,33.66 61.55,33.39 v1(61.55,32.42)
  TOP w0.203: 60.43,36.38 60.43,36.56 60.31,36.69 U9.9
  TOP w0.305: 60.43,36.38 60.43,35.36 61.64,34.15 R219.2
RSMRST#: length 119.5
  IN3 w0.114: v2(189.82,50.6) 189.73,50.51 189.37,50.51 188.04,49.18 188.04,46.5 190.74,43.8 192.64,43.8 198.81,37.63 201.16,37.63 201.55,37.24 210.25,37.24 210.55,36.93 213.27,36.93 213.52,37.18 214.92,37.18 215.57,36.54 221.27,36.54 221.63,36.9 229.08,36.9 229.47,36.51 231.86,36.51 232.06,36.71 238.97,36.71 v2(239.94,37.68)
  BOTTOM w0.076: 161.12,76.03 161.12,76.52 160.85,76.78 158.34,76.78 157.27,77.85 157.27,78.56 157.06,78.78 157.06,79.47 U14.AW6
  BOTTOM w0.102: U23.80 236.45,38.29 236.61,38.44 238.62,38.44 238.77,38.29 239.66,38.29 239.94,38.01 v2(239.94,37.68) ; v2(189.82,50.6) 189.75,50.67 189.75,52.1 188.02,53.82 v1(188.02,56.58) 188.02,57.29 179.43,65.89 179.43,67.01 178.08,68.36 164.56,68.36 162.29,70.64 162.29,73.06 161.82,73.53 R404.1 161.65,73.65 161.65,74.88 R390.2 161.32,74.93 161.12,75.13 161.12,76.03
RSVD_PGDMON: length 11.3
  TOP w0.102: v2(153.3,81.55) 153.3,78.95 152.36,78.01 R106.1 151.88,77.21 151.68,77.01 v1(151.68,75.27)
  BOTTOM w0.076: U14.AL11 154.14,84.42 154.14,84.24 154.21,84.16 154.21,84.11 154.21,84.11 154.21,83.87 154.21,83.86 154.21,83.8 154.19,83.78 154.19,83.48 154.26,83.41 154.26,83.2 154.19,83.13 154.19,82.89 154.26,82.82 154.26,82.55 154.19,82.48 154.19,82.24 154.26,82.17 154.26,81.96 153.87,81.57 153.32,81.57 v2(153.3,81.55)
RT8240BST: length 3.2
  BOTTOM w0.102: PR128.2 206.61,125.66 v1(206.74,125.79)
  BOTTOM w0.203: 207.02,123.71 207.35,123.38 PU8.4
  BOTTOM w0.508: PR128.2 206.61,124.12 207.02,123.71
RT8240DH: length 15
  TOP w0.102: v1(192.95,125.84) 193.35,126.25 v2(193.35,126.4)
  IN1 w0.762: v3(205.77,123.05) 196.71,123.05 193.91,125.84
  BOTTOM w0.203: PU8.3 206.46,122.36 v3(205.77,123.05)
RT8240DL: length 9
  BOTTOM w0.203: PU8.1 206.36,121.56 206.03,121.22
  BOTTOM w0.762: 206.03,121.22 v1(203.01,118.2) 201.13,116.32 PQ28.4
RT8240EN: length 6
  BOTTOM w0.102: v1(212.63,120.94) 212.32,121.26 PR136.1
  BOTTOM w0.203: PU8.8 210.38,121.96 PC102.1 210.81,122.39 211.79,122.39 PR136.1 PR134.1
RT8240FB: length 6.8
  TOP w0.254: PR7.2 208.78,118.96 v1(208.78,120.26) v2(208.78,123.25)
  BOTTOM w0.203: PR124.1 209.02,123.5 v2(208.78,123.25) 208.72,123.3 208.26,123.3 208.16,123.2 PU8.6
RT8240ILIM: length 5.4
  BOTTOM w0.102: PR149.2 209.48,119.17 210.45,118.2 210.45,117.03 v1(210.7,116.78)
  BOTTOM w0.203: PR149.2 208.16,120.22 PU8.10
RT8240LX: length 14.3
  IN1 w0.762: v3(205.67,122.03) 194.39,122.03 v2(193.56,121.19)
  BOTTOM w0.203: PU8.2 205.74,121.96 v3(205.67,122.03)
  BOTTOM w0.508: v3(205.67,122.03) 205.62,122.03 PC98.1
RT8240RGND: length 3.6
  BOTTOM w0.102: PR130.1 v1(210.54,125.06)
  BOTTOM w0.203: PR130.1 209.84,123.36 209.84,123.13 209.07,122.36 PU8.7
RT8240TON: length 3.9
  BOTTOM w0.102: v1(205.95,119.17) PR150.2
  BOTTOM w0.203: 207.75,119.62 207.3,119.17 PR150.2 ; 207.75,119.62 PU8.11 ; 207.75,119.62 207.75,119.6 PR148.1
RT8240VCC: length 3.7
  TOP w0.254: v2(208.49,123.91) 208.29,123.71 PR1.2
  BOTTOM w0.203: v2(208.49,123.91) 208.49,124.14 208.29,124.34 PC84.2 PU8.5
RTC_RST#: length 40.2
  TOP w0.102: v1(154.58,73.81) 154.95,73.81 155.31,74.16 C190.1 156.02,73.7 156.8,73.7 157.07,73.97 157.07,75.89 156.18,76.78 156.18,77.49 155.68,77.99 155.68,80.05 v2(156.39,80.76) ; v1(154.58,73.81) 154.58,74.16 153.78,74.97 152.69,74.97 151.52,73.8 151.52,68.86 152.4,67.98 159.86,67.98 161.46,69.58 167.37,69.58 168.26,70.47 Q47.3 ; v1(154.58,73.81) 154.41,73.64 R119.1
  BOTTOM w0.076: U14.AU7 156.09,81.06 v2(156.39,80.76)
RTC_X1: length 15.8
  BOTTOM w0.076: U14.AW5 157.52,79.56 157.64,79.44 157.69,79.44 157.88,79.25 157.88,78.8
  BOTTOM w0.102: v1(167.67,73.77) 167.47,73.57 167.02,73.57 Y3.1 165.84,73.01 165.6,73.26 165.6,74.15 166.09,74.64 C457.2 165.73,74.92 R385.1 163.67,76.97 162.16,76.97 161.81,77.33 158.63,77.33 157.82,78.14 157.82,78.74 157.88,78.8
RTC_X2: length 17.3
  BOTTOM w0.102: U14.AY5 157.55,78.81 157.64,78.73 157.64,78.07 158.56,77.15 161.65,77.15 162.11,76.69 163.17,76.69 R385.2 164.71,75.15 C458.2 164.71,74.48 164.91,74.28 164.91,73.37 164.55,73.01 Y3.2 163.96,72.46 164.73,71.69 167.17,71.69 167.62,72.15 v1(167.62,72.4)
RUN_ENABLE_1: length 31.2
  TOP w0.203: PU6.10 205.51,22.63 v2(205.95,22.19)
  TOP w0.254: PR116.2 233.39,19.86 232.67,19.14 v1(214.77,19.14) 214.77,19.21 v2(213.34,20.64)
  IN3 w0.254: v2(205.95,22.19) 207.55,22.19 208.87,20.86 210.8,20.86 211.03,20.64 v2(213.34,20.64)
RUN_ENABLE_2: length 36.1
  TOP w0.102: PU6.11 203.73,23.13 203.85,23.01 205.79,23.01 206.69,22.11 206.69,21.3 205.37,19.98 v2(204.83,19.98) ; v2(189.52,24.7) 189.52,24.8 189.26,25.06 189.26,28.84 188.48,29.63 188.48,30.95 189.85,32.32 191.46,32.32 PR71.2
  IN3 w0.114: v2(204.83,19.98) 202.47,19.98 202.45,20 202.22,20 200.31,21.91 190.66,21.91 189.52,23.05 v2(189.52,24.7)
