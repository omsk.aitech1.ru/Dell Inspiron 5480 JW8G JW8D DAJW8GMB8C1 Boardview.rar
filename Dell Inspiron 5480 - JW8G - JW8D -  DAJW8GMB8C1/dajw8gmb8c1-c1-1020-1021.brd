# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VIN on BOTTOM (solid shape): 260.69,25.41 260.69,23.74 260.18,23.23 259.93,23.23 259.6,23.56 259.6,23.89 259.01,24.47 259.01,25.51 259.24,25.74 260.36,25.74
+VIN on BOTTOM (solid shape): 206.31,126.35 206.31,125.61 205.9,125.21 204.58,125.21 204.53,125.16 204.53,123.48 204.4,123.35 199.42,123.35 199.17,123.61 195.54,123.61 195.27,123.88 195.27,126.4 195.49,126.63 206.03,126.63
+VIN on BOTTOM (solid shape): 155.66,25.64 155.66,23.82 156.25,23.23 156.25,18.47 155.97,18.18 155.97,16.75 155.88,16.66 149.45,16.66 149.23,16.88 149.23,18.68 150.33,19.77 150.33,20.13 150.48,20.28 153.22,20.28 153.6,20.66 153.6,21.42 154.32,22.13 154.32,25.82 154.59,26.1 155.2,26.1
+VIN on BOTTOM (solid shape): 125.56,21.17 130.51,21.17 132.08,19.6 138.49,19.6 138.81,19.28 138.81,16.75 138.54,16.48 136.36,16.48 136.11,16.73 136.1,16.73 135.93,16.9 133.74,16.9 133.39,16.55 125.41,16.55 124.86,17.11 122.53,17.11 122.2,16.78 119.27,16.78 119.13,16.93 119.13,19.53 119.36,19.76 121.71,19.76 122.13,20.18 122.13,21.2 122.31,21.37 125.36,21.37
+VIN on BOTTOM (solid shape): 121.37,123.02 121.37,118.78 121.45,118.71 121.45,118.4 121.34,118.3 121.06,118.3 120.89,118.48 118.73,118.48 118.36,118.11 118.09,118.11 117.86,118.33 117.86,121.68 118.13,121.94 118.16,121.94 118.57,122.08 118.65,122.51 118.64,122.54 119.02,122.92 119.92,122.92 120.07,123.07 121.32,123.07
+VIN on BOTTOM (solid shape): 219.28,58.18 219.28,52.7 220.58,51.4 223.12,51.4 223.3,51.22 223.3,50 223.16,49.86 216.89,49.86 216.52,49.49 216.52,47.89 216.87,47.53 218.85,47.53 219.07,47.32 219.07,47.14 219.11,47.1 219.11,45.76 217.97,44.61 217.97,42.35 217.86,42.25 214.46,42.25 214.26,42.45 214.24,42.45 214.24,46.61 214.79,47.15 214.79,47.99 214.66,48.12 208.52,48.12 208.24,47.84 207.27,47.84 207.21,47.9 207.21,51.03 207.37,51.19 207.37,54.36 207.64,54.63 213.26,54.63 213.65,55.02 213.65,58.08 214.15,58.58 218.88,58.58
+VIN on BOTTOM (solid shape): 153.6,123.3 155.25,123.3 155.66,122.9 155.66,118.45 155.28,118.07 152.46,118.07 151.77,118.76 150.55,118.76 150.47,118.8 150.46,118.9 150.43,119.33 150.04,119.52 149.73,119.59 149.46,119.44 149.31,119.38 149.19,119.27 148.17,119.27 148.17,122.44 148.37,122.64 149.16,122.64 149.17,122.66 151.02,122.66 151.68,123.32 153.59,123.32
+VIN on BOTTOM (solid shape): outline of 680 points within 31.76,24.8 79.99,55.71
+VIN on IN1 (solid shape): outline of 320 points within 55.63,16.73 87.79,23.05
+VIN on IN2 (solid shape): 216.94,47.55 219.02,47.55 219.4,47.17 219.4,45.9 218.85,45.35 214.26,45.35 213.75,45.86 213.75,47.51 213.95,47.71 216.77,47.71
+VIN on IN2 (solid shape): 260.84,25.51 260.84,24.17 260.64,23.96 260.64,23.43 260.41,23.2 259.95,23.2 259.6,23.56 259.6,23.91 258.66,24.85 258.66,25.18 259.39,25.92 260.43,25.92
+VIN on IN2 (solid shape): outline of 4483 points within 99.37,73.75 207.88,126.66
+VIN on IN2 (solid shape): outline of 6395 points within 36.36,16.73 221.09,46.02
+VIN on IN3 (solid shape): 107.2,102.75 107.2,101.81 105.34,99.96 104.83,99.96 104.83,102.91 105.19,103.26 106.69,103.26
+VIN on IN3 (solid shape): 101.63,78.9 101.63,78.22 101.35,77.94 101.35,74.31 101.2,74.15 99.65,74.15 99.42,74.38 99.42,77.3 100.01,77.89 100.01,78.55 100.77,79.31 101.23,79.31
AGND on TOP (solid shape): 328.28,36.56 328.28,35.95 328.02,35.7 322.57,35.7 322.56,35.71 321.68,35.71 321.57,35.83 321.57,36.64 321.65,36.72 322.59,36.72 322.6,36.74 328.1,36.74
AGND on TOP (solid shape): 319.08,36.64 319.08,35.84 318.96,35.71 318.9,35.71 318.14,35.17 318.39,34.27 318.39,29.33 318.14,28.43 318.9,27.89 319.11,27.89 319.21,27.79 319.21,27.11 319.11,27.01 318.21,27.01 317.16,28.16 317.38,29.7 317.38,33.9 317.29,35.77 318.9,36.72 319,36.72
AGND on BOTTOM (solid shape): 328.28,36.56 328.28,35.95 328.02,35.7 322.57,35.7 322.56,35.71 321.34,35.71 321.25,35.76 321.25,35.87 321.35,36.22 321.23,36.56 321.22,36.67 321.31,36.72 322.59,36.72 322.6,36.74 328.1,36.74
AGND on BOTTOM (solid shape): 314.59,41.1 314.59,40.55 316.09,39.05 316.09,38.3 314.08,36.29 314.01,36.26 313.94,36.3 313.46,36.34 313.37,35.87 313.37,35.76 313.28,35.71 312.19,35.71 311.96,35.94 311.96,36.68 312.13,36.85 312.95,36.85 313.79,37.69 313.79,38.24 313.47,38.55 313.47,39.95 313.15,40.27 312.98,40.27 312.94,40.31 312.94,41.19 313.02,41.28 314.41,41.28
AGND on BOTTOM (solid shape): 319.08,36.64 319.08,35.84 318.96,35.71 318.9,35.71 318.14,35.17 318.39,34.27 318.39,29.33 318.1,28.83 318.22,28.26 318.22,28.15 318.06,28 317.22,28 317.08,28.87 317.38,29.7 317.38,33.9 317.29,35.77 318.9,36.72 319,36.72
AGND on SGND (solid shape): 318.27,38.09 328.29,38.09 328.29,35.71 318.9,35.71 318.86,35.71 318.69,35.71 318.65,35.67 318.1,35.05 318.39,34.27 318.39,29.33 318.1,28.55 318.65,27.93 318.69,27.89 318.86,27.89 318.9,27.89 328.29,27.89 328.29,26.51 316.51,26.51 316.11,26.91 311.03,26.91 309.25,25.13 304.51,25.13 303.85,25.79 301.3,25.79 300.87,25.36 297.32,25.36 297.26,25.41 297.26,27.14 297.45,27.32 298.23,27.32 298.86,26.68 300.64,26.68 300.69,26.68 301.89,26.68 302.62,27.41 302.62,30.61 303.49,31.48 304.04,31.48 304.15,31.38 304.15,30.55 303.64,30.04 303.64,28.79 303.31,28.43 303.64,28.08 303.64,27.31 304.8,26.15 306.67,26.15 307.32,26.8 307.32,29.3 306.43,30.19 306.43,31.38 306.54,31.48 307.85,31.48 307.88,31.46 308.59,31.46 308.67,31.38 308.67,30.39 309.51,29.55 309.89,29.55 310.14,29.8 310.14,31.13 309.35,31.92 309.35,37.18 308.95,37.58 308.57,37.58 308.47,37.68 308.47,39.25 309.35,40.14 309.35,40.9 309.84,41.39 314.96,41.39
AGND on IN1 (solid shape): 328.28,36.56 328.28,35.95 328.02,35.7 322.57,35.7 322.56,35.71 321.34,35.71 321.25,35.76 321.25,35.87 321.35,36.22 321.23,36.56 321.22,36.67 321.31,36.72 322.59,36.72 322.6,36.74 328.1,36.74
AGND on IN1 (solid shape): 319.08,36.64 319.08,35.84 318.96,35.71 318.9,35.71 318.14,35.17 318.39,34.27 318.39,29.33 318.14,28.43 318.9,27.89 319.32,27.89 319.36,27.85 319.36,27.76 319.26,27.52 319.26,27.26 319.25,27.24 317.8,27.24 317.1,28.39 317.38,29.7 317.38,33.9 317.29,35.77 318.9,36.72 319,36.72
AGND on SVCC (solid shape): outline of 112 points within 297.26,25.13 326.77,41.39
AGND on IN2 (solid shape): 328.28,36.56 328.28,35.95 328.02,35.7 322.57,35.7 322.56,35.71 321.83,35.71 321.57,35.96 321.57,36.55 321.75,36.72 322.59,36.72 322.6,36.74 328.1,36.74
AGND on IN2 (solid shape): 319.08,36.64 319.08,35.84 318.96,35.71 318.9,35.71 318.14,35.17 318.39,34.27 318.39,29.33 318.14,28.43 318.9,27.89 319.31,27.89 319.34,27.87 319.34,27.74 319.23,27.42 319.31,27.1 319.31,27.04 319.29,27.01 318.21,27.01 317.16,28.16 317.38,29.7 317.38,33.9 317.29,35.77 318.9,36.72 319,36.72
AGND on IN3 (solid shape): 328.28,36.56 328.28,35.95 328.02,35.7 322.57,35.7 322.56,35.71 321.95,35.71 321.67,35.99 321.67,36.6 321.8,36.72 322.59,36.72 322.6,36.74 328.1,36.74
AGND on IN3 (solid shape): 319.08,36.64 319.08,35.84 318.96,35.71 318.9,35.71 318.14,35.17 318.39,34.27 318.39,29.33 318.14,28.43 318.9,27.89 318.96,27.89 319.06,27.8 319.06,27.17 318.91,27.01 318.21,27.01 317.16,28.16 317.38,29.7 317.38,33.9 317.29,35.77 318.9,36.72 319,36.72
AGND on SGND1 (solid shape): 318.27,38.09 328.29,38.09 328.29,35.71 318.9,35.71 318.86,35.71 318.69,35.71 318.65,35.67 318.1,35.05 318.39,34.27 318.39,29.33 318.1,28.55 318.65,27.93 318.69,27.89 318.86,27.89 318.9,27.89 328.29,27.89 328.29,26.51 316.52,26.51 316.11,26.91 311.03,26.91 309.25,25.13 304.5,25.13 303.84,25.79 301.3,25.79 300.87,25.36 297.32,25.36 297.26,25.41 297.26,27.14 297.45,27.32 298.23,27.32 298.86,26.68 301.89,26.68 302.62,27.41 302.62,30.61 303.49,31.48 304.04,31.48 304.15,31.38 304.15,30.54 303.64,30.03 303.64,28.79 303.31,28.43 303.64,28.08 303.64,27.31 304.8,26.15 306.67,26.15 307.32,26.8 307.32,29.3 306.43,30.19 306.43,31.38 306.54,31.48 307.85,31.48 307.88,31.46 308.59,31.46 308.67,31.38 308.67,30.39 309.5,29.55 309.89,29.55 310.14,29.8 310.14,31.13 309.35,31.92 309.35,37.18 308.95,37.58 308.57,37.58 308.47,37.68 308.47,39.25 309.35,40.14 309.35,40.9 309.84,41.39 314.96,41.39
AV12 on IN2 (solid shape): outline of 220 points within 60.89,34.96 64.73,43.32
GND on TOP (solid shape): 18.5,82.56 18.5,80.71 18.4,80.61 17.33,80.61 17.2,80.73 17.2,82.61 17.28,82.69 18.37,82.69
GND on TOP (solid shape): 158.43,75.35 158.43,74.13 158.25,73.95 157.87,73.95 157.54,74.28 157.54,75.53 157.59,75.58 158.2,75.58
GND on TOP (solid shape): 192.9,108.95 192.9,107.25 192.72,107.07 191.24,107.07 190.94,107.38 190.94,108.83 191.12,109 192.85,109
GND on TOP (solid shape): 288.83,42.43 288.83,41.34 288.76,41.26 287.13,41.26 286.7,41.69 286.7,42.18 287.03,42.51 288.76,42.51
GND on TOP (solid shape): 314.18,64.25 314.18,61.84 313.8,61.45 311.89,61.45 311.26,62.09 311.26,64.38 311.64,64.76 313.67,64.76
GND on TOP (solid shape): 130.13,119.01 130.13,117.21 129.7,116.78 126.96,116.78 126.65,117.08 126.65,118.91 126.86,119.11 130.03,119.11
GND on TOP (solid shape): 149.33,123.56 149.33,121.65 148.7,121.02 146.16,121.02 145.8,121.37 145.8,123.71 145.96,123.86 149.03,123.86
GND on TOP (solid shape): 167.04,74.15 167.04,72.32 166.83,72.11 163.89,72.11 163.71,72.28 163.71,73.98 163.91,74.19 163.91,74.42 164.05,74.55 166.63,74.55
GND on TOP (solid shape): 178.04,65.67 179.1,65.67 179.26,65.52 179.26,65.01 179.15,64.91 177.83,64.91 176.89,65.85 176.89,66.15 177.05,66.31 177.4,66.31
GND on TOP (solid shape): 250,38.01 250,37.48 248.88,36.36 247.23,36.36 247.2,36.38 247.2,37.93 247.38,38.11 249.89,38.11
GND on TOP (solid shape): 291.74,40.99 291.74,40.37 290.98,39.61 289.54,39.61 289.47,39.69 289.47,40.78 289.59,40.91 290.99,40.91 291.19,41.11 291.63,41.11
GND on TOP (solid shape): 64.47,39.53 64.47,36.36 64.3,36.18 62.7,36.18 62.59,36.28 62.59,37.71 62.9,38.01 62.9,39.51 62.97,39.58 64.42,39.58
GND on TOP (solid shape): 160.48,70.71 160.48,70.12 159.6,69.25 156.32,69.25 156.19,69.38 156.19,69.96 156.32,70.09 158.89,70.09 159.76,70.96 160.22,70.96
GND on TOP (solid shape): 177.3,93.53 177.3,93.13 177.53,92.9 177.53,92.14 177.4,92.01 176.87,92.01 176.77,92.11 176.77,92.7 175.93,93.53 175.93,93.79 175.95,93.81 177.02,93.81
GND on TOP (solid shape): 179.03,48.93 179.03,48.09 178.93,47.99 178.04,47.99 177.83,47.79 176.89,47.79 176.79,47.89 176.79,48.7 177.15,49.06 178.9,49.06
GND on TOP (solid shape): 201.33,61.1 201.33,58 201,57.67 198.05,57.67 195.84,59.88 195.84,60.44 195.99,60.59 195.99,61.3 196.12,61.43 201,61.43
GND on TOP (solid shape): 151.04,115.66 150.05,114.67 144.99,114.67 144.71,114.95 144.71,116.62 145.04,116.95 148.8,116.95 149.11,117.26 149.11,117.72 149.16,117.77 151.04,117.77
GND on TOP (solid shape): 193.53,76.34 193.53,73.67 193.35,73.49 191.22,73.49 190.99,73.72 190.99,75.42 191.25,75.68 192.21,75.68 192.44,75.91 192.44,76.65 192.49,76.69 193.18,76.69
GND on TOP (solid shape): 206.82,115.51 206.82,112.28 205.65,111.11 205.29,111.11 204.73,110.55 204.73,109.87 203.92,109.87 203.92,110.7 204.61,111.39 204.61,115.4 204.86,115.66 206.66,115.66
GND on TOP (solid shape): 211.62,36.05 211.62,35.47 211.49,35.34 210.78,35.34 210.68,35.24 210.68,34.89 210.57,34.78 210.04,34.78 209.94,34.89 209.94,35.95 210.17,36.18 211.49,36.18
GND on TOP (solid shape): 124.65,119.98 124.65,116.67 123.81,115.84 119.39,115.84 118.74,116.48 118.74,117.99 119.19,118.43 121.8,118.43 121.86,118.49 121.86,120.75 122.13,121.02 123.6,121.02
GND on TOP (solid shape): 156.62,110.07 156.62,109.36 157.23,108.75 157.23,108.19 157.11,108.06 156.4,108.06 155.86,107.53 155.51,107.53 155.41,107.63 155.41,108.06 155.66,108.32 155.66,110.1 155.8,110.23 156.46,110.23
GND on TOP (solid shape): 182.3,38.85 182.3,38.49 182.23,38.42 181.95,38.42 181.69,38.16 181.69,37.81 182.13,37.37 182.13,34.76 181.96,34.59 181.17,34.59 181.08,34.68 181.08,39.28 181.21,39.41 181.75,39.41
GND on TOP (solid shape): 276.26,42.25 276.26,40.02 276.44,39.84 277,39.84 277.4,39.43 277.4,38.06 277.05,37.71 276.08,37.71 275.93,37.86 275.42,37.86 275.29,37.98 275.29,41.16 275.47,41.34 275.47,42.35 276.16,42.35
GND on TOP (solid shape): 199.17,109.71 199.4,109.49 200.59,109.49 200.77,109.66 200.77,110.25 200.95,110.43 201.42,110.43 201.72,110.12 201.72,108.3 201.51,108.09 198.13,108.09 198.13,110.43 198.28,110.58 199.17,110.58
GND on TOP (solid shape): 285.61,46.47 285.61,46.21 283.75,44.36 283.75,42.45 283.7,42.4 283.19,42.4 283.17,42.43 282.61,42.43 282.6,42.44 282.14,42.44 281.8,42.79 281.8,45.07 283.32,46.6 285.48,46.6
GND on TOP (solid shape): 192.91,79.39 192.91,79.22 192.32,78.64 192.32,76.21 192.12,76.01 189.2,76.01 189.12,75.93 189.12,75.48 189.02,75.37 188.72,75.37 188.62,75.48 188.62,77.88 189.69,78.95 191.85,78.95 192.43,79.54 192.76,79.54
GND on TOP (solid shape): 271.61,36.82 271.61,35.95 271.56,35.9 269.96,35.9 269.55,35.5 269.55,34.78 269.17,34.4 266.56,34.4 266.4,34.56 266.4,35.77 266.86,36.23 269.32,36.23 269.96,36.87 271.56,36.87
GND on TOP (solid shape): 212.02,68.59 212.02,68.34 211.87,68.19 199.22,68.19 198.56,68.85 198.56,68.94 198.2,69.31 197.4,69.31 197.02,69.68 197.02,71.73 196.07,72.68 196.07,77.18 197.95,79.06 201.56,79.06
GND on TOP (solid shape): 130.84,26.45 130.84,25.49 130.86,25.47 131.05,25.47 131.07,25.49 131.07,26.45 131.11,26.49 131.32,26.49 131.34,26.46 131.34,25.32 131.35,25.12 131.41,25.07 131.41,24.15 131.35,24.1 130.52,24.1 130.29,24.33 130.29,25.04 130.57,25.32 130.57,26.46 130.6,26.49 130.81,26.49
GND on TOP (solid shape): 203.26,27.49 203.26,26.73 203.59,26.4 203.59,25.92 203.46,25.79 201.79,25.79 201.78,25.79 199.82,25.79 199.52,26.1 198.36,26.1 198.31,26.15 198.31,26.71 197.86,27.15 197.86,27.59 197.95,27.68 198.15,27.68 198.15,27.67 201.51,27.67 201.86,28.03 202.73,28.03
GND on TOP (solid shape): 301.61,45.96 301.61,44.16 301.4,43.95 301.02,43.95 301,43.98 301,43.99 300.95,44.04 299.53,44.04 299.32,44.11 299.12,44.04 298.19,44.04 297.54,44.69 297.54,46.34 297.8,46.6 300.97,46.6
GND on TOP (solid shape): 40.5,29.7 40.5,29.2 40.97,28.72 41.71,28.72 42.13,28.29 42.13,26.86 42.09,26.83 40.56,26.83 40.5,26.89 40.5,27.58 40.21,27.87 40.21,28.59 39.99,28.82 39.73,28.82 39.48,29.07 39.48,29.16 39.51,29.3 39.48,29.44 39.48,29.7 39.61,29.83 40.37,29.83
GND on TOP (solid shape): 184.26,80.45 184.26,78.88 183.83,78.45 183.83,77.79 184.11,77.51 184.11,75.6 183.97,75.46 183.28,75.46 183.22,75.53 183.22,76.29 182.96,76.55 182.84,76.95 182.44,77.07 182.15,77.35 182.15,80.53 182.25,80.63 184.08,80.63
GND on TOP (solid shape): 127.85,96.4 127.85,95.59 128.13,95.31 142.81,95.31 142.98,95.13 142.98,90.56 142.83,90.41 141.74,90.41 141.46,90.69 141.46,91.05 141.59,91.17 141.59,92.57 141.05,93.1 130.62,93.1 130.03,92.52 130.03,87.59 128.96,86.52 127.87,86.52 127.69,86.7 127.69,93.56 127.36,93.89 126.78,93.89 126.58,94.09 126.58,95.34 126.55,95.36 126.55,95.64 126.63,95.72 126.63,96.43 126.73,96.53 127.72,96.53
GND on TOP (solid shape): 257.36,33.84 257.36,32.47 257.62,32.22 258.58,32.22 258.63,32.17 258.63,32.07 258.55,31.99 257.67,31.99 257.49,31.81 257.49,29.93 257.62,29.81 257.62,28 257.59,27.98 257.46,27.98 257.42,28.01 257.42,29.39 257.16,29.65 255.15,29.65 254.62,29.12 254.62,28.03 254.57,27.98 254.41,27.98 254.39,28 254.39,29.75 254.31,29.83 252.69,29.83 252.26,30.26 252.26,33.23 251.95,33.54 250.93,33.54 250.88,33.59 250.88,33.69 250.91,33.72 251.7,33.72 252.13,34.15 257.06,34.15
GND on TOP (solid shape): 178.4,28.05 178.54,27.92 180.2,27.92 180.3,27.82 180.3,27.2 180.06,26.96 180.06,25.87 180,25.81 178.53,25.81 178.41,25.93 176.64,25.93 176.43,25.72 174.97,25.72 174.41,26.28 174.41,26.51 174.43,26.54 175.7,26.54 175.93,26.45 176.16,26.54 176.21,26.54 176.41,26.74 176.41,27.58 176.67,27.83 177.18,27.83 177.43,28.09 177.43,28.46 177.49,28.52 177.94,28.52
GND on TOP (solid shape): 168.36,29.34 168.36,27.74 168.18,27.57 167.96,27.57 167.16,26.77 167.16,26.56 165.11,24.51 164.02,24.51 163.69,24.84 163.69,26.97 165.38,28.66 165.45,28.69 165.53,28.66 165.92,28.56 166.15,28.9 166.15,28.95 166.77,28.95 167.28,29.47 168.23,29.47
GND on TOP (solid shape): 232.95,25.11 232.95,24.8 232.77,24.62 232.39,24.62 232.14,24.73 231.89,24.62 231.37,24.62 231.12,24.73 230.87,24.62 230.69,24.62 230.49,24.42 230.49,23.56 228.89,21.96 217.54,21.96 216.25,23.25 209.33,23.25 208.87,23.71 208.87,25.11 208.97,25.21 232.85,25.21
GND on TOP (solid shape): 152.92,94.58 152.92,92.59 152.43,92.11 152.43,89.32 152.57,89.18 152.98,89.18 153.2,88.96 153.2,88.71 153.4,88.51 153.65,88.51 154.03,88.89 154.8,88.89 155.41,88.28 155.41,87.82 155.35,87.77 152.79,87.77 152.51,88.05 149.87,88.05 149.74,88.17 149.74,88.43 149.89,88.58 149.89,88.86 149.49,89.27 149.49,90.28 149.36,90.41 149.36,90.61 149.46,90.71 149.46,91.45 149.3,91.62 149.3,91.82 149.61,92.14 149.61,94.09 149.74,94.22 150.45,94.22 150.78,93.89 152.21,93.89 152.33,94.02 152.33,94.63 152.43,94.73 152.76,94.73
GND on TOP (solid shape): 173.92,28.95 174.02,28.95 174.13,28.84 174.13,28.21 174.3,28.04 175.48,28.04 175.48,28.05 175.52,28.05 175.69,27.87 175.69,27.42 175.55,27.28 174.28,27.28 174.13,27.12 174.13,26.39 174.03,26.28 170.27,26.28 170.24,26.31 170.24,26.51 170.27,26.54 171.23,26.54 171.23,26.55 171.23,26.76 171.23,26.77 170.26,26.77 170.24,26.79 170.24,27.01 170.28,27.04 171.38,27.04 171.54,27.2 171.54,27.77 174.43,27.77 174.43,27.54 174.44,27.54 175.42,27.54 175.43,27.54 175.43,27.77 175.41,27.78 174.45,27.78 174.43,27.77 171.54,27.77 171.54,28.9 171.62,28.98 173.9,28.98
GND on TOP (solid shape): 123.91,126.2 123.91,123.81 123.53,123.43 119.13,123.43 119.06,123.51 119.06,124.85 120.73,124.85 120.74,124.8 120.75,124.75 120.77,124.7 120.8,124.65 120.83,124.61 120.87,124.57 120.91,124.54 120.96,124.52 121.01,124.5 121.06,124.5 121.12,124.5 121.17,124.5 121.22,124.52 121.27,124.54 121.31,124.57 121.35,124.61 121.39,124.65 121.41,124.7 121.43,124.75 121.44,124.8 121.45,124.85 121.44,124.91 121.43,124.96 121.41,125.01 121.39,125.05 121.35,125.1 121.31,125.13 121.27,125.16 121.22,125.18 121.17,125.2 121.12,125.21 121.06,125.21 121.01,125.2 120.96,125.18 120.91,125.16 120.87,125.13 120.83,125.1 120.8,125.05 120.77,125.01 120.75,124.96 120.74,124.91 120.73,124.85 119.06,124.85 119.06,126.27 119.32,126.54 123.57,126.54
GND on TOP (solid shape): 318.59,42.12 322.14,42.12 322.14,41.78 322.44,41.06 323.15,40.77 325.05,40.77 325.76,41.06 326.06,41.78 326.06,42.12 328.99,42.12 328.99,40.14 328.29,40.14 328.29,38.84 328.09,38.63 326.11,38.63 325.23,39.51 322.11,39.51 321.19,40.42 318.26,40.42 317.58,41.1 317.58,43.02 318.59,43.02
GND on TOP (solid shape): 196.05,100.01 196.05,99.63 196.25,99.43 197.87,99.43 198.03,99.27 198.03,98.87 198,98.8 197.93,98.77 197.68,98.18 198.3,98.32 198.31,98.36 199.4,98.36 199.55,98.21 199.55,97.57 199.47,97.5 197.82,97.5 197.7,97.37 197.39,97.37 197.31,97.4 197.29,97.48 197.25,97.69 197.1,97.84 196.63,98.31 196.63,98.59 196.35,98.87 195.64,98.87 195.56,98.94 195.56,99.68 195.26,99.99 195.26,100.32 195.36,100.42 195.64,100.42
GND on TOP (solid shape): 15.65,71.39 15.65,66.92 15.07,66.33 13.25,66.33 13.19,65.84 13,65.39 13,64.36 12.95,64.27 12.84,64.28 12.5,64.4 12.14,64.32 12.04,64.33 11.99,64.42 11.99,65.72 12,65.75 12.01,65.76 12.18,66.59 11.48,67.06 2.51,67.06 2.51,70.14 8.67,70.14 9.17,69.64 12.39,69.64 12.39,71.97 12.82,72.4 14.64,72.4
GND on TOP (solid shape): 318.01,64.78 318.01,63.66 317.81,62.83 318.52,62.34 328.29,62.34 328.29,59.42 328.99,59.42 328.99,57.43 326.06,57.43 326.06,57.78 325.76,58.49 325.05,58.78 323.15,58.78 322.44,58.49 322.14,57.78 322.14,57.43 319.49,57.43 317.62,59.31 317.59,59.31 317.56,59.28 316.53,59.28 314.87,60.95 314.87,62.62 315.58,63.33 316.32,63.33 317,64.01 317,64.78 317.08,64.86 317.94,64.86
GND on TOP (solid shape): 328.29,25.61 328.29,18.7 328.15,18.35 327.8,18.21 318.97,18.21 318.04,19.14 318.04,24.19 317.63,24.61 316.83,24.61 316.75,24.61 312.75,24.61 311.68,24.17 311.24,23.1 311.24,22.1 311.1,21.75 310.75,21.61 303.32,21.61 303.22,21.69 303.28,21.8 303.8,22.14 304.17,22.62 310.23,22.62 310.23,23.1 310.97,24.88 312.75,25.62 316.75,25.62 316.84,25.62 316.94,25.62 316.97,25.65 317.59,25.65 317.71,25.77 328.14,25.77
GND on TOP (solid shape): 267.35,22.57 267.82,21.96 268.53,22.25 268.62,22.3 268.71,22.25 269.42,21.96 269.89,22.57 269.89,22.62 271.16,22.62 271.16,22.57 271.63,21.96 272.34,22.25 272.43,22.3 272.52,22.25 273.23,21.96 273.7,22.57 273.7,22.62 280.05,22.62 280.05,22.57 280.52,21.96 281.23,22.25 281.32,22.3 281.95,21.93 282.59,22.3 282.68,22.25 283.39,21.96 283.86,22.57 283.86,22.62 287.67,22.62 287.67,22.57 288.14,21.96 288.85,22.25 288.94,22.3 289.57,21.93 290.21,22.3 290.3,22.25 291.01,21.96 291.48,22.57 291.48,22.62 292.75,22.62 292.75,22.57 293.38,21.93 294.02,22.57 294.02,22.62 295.29,22.62 295.29,22.57 295.76,21.96 296.47,22.25 296.56,22.3 297.19,21.93 297.83,22.3 297.92,22.25 298.63,21.96 299.1,22.57 299.1,22.62 299.37,22.62 299.49,22.13 299.8,21.79 299.84,21.68 299.74,21.61 265.45,21.61 265.35,21.68 265.39,21.79 265.7,22.13 265.82,22.57 265.82,22.62 267.35,22.62
GND on TOP (solid shape): outline of 604 points within 187.43,88.89 200.8,99.31
GND on TOP (solid shape): outline of 166 points within 2.51,0.51 260.89,55.13
GND on TOP (solid shape): outline of 1581 points within 0.51,49.38 328.29,128.19
GND on BOTTOM (solid shape): 72.99,25.02 72.99,21.34 72.49,20.83 71.34,20.83 71.22,20.95 71.22,24.89 71.47,25.15 72.87,25.15
GND on BOTTOM (solid shape): 83.28,30.86 83.28,28.83 82.65,28.19 80.61,28.19 80.49,28.32 80.49,30.86 80.61,30.99 83.15,30.99
GND on BOTTOM (solid shape): 105.09,51.9 105.09,50.18 104.55,49.64 102.24,49.64 101.76,50.13 101.76,51.8 102.14,52.18 104.81,52.18
GND on BOTTOM (solid shape): 138.44,112.53 138.44,111.16 137.5,110.22 130.18,110.22 129.75,110.65 129.75,112.51 129.9,112.66 138.31,112.66
GND on BOTTOM (solid shape): 158.17,17.74 158.17,15.99 157.95,15.76 156.52,15.76 156.29,15.99 156.29,17.87 156.47,18.05 157.87,18.05
GND on BOTTOM (solid shape): 291.77,41.76 291.77,40.35 291.08,39.66 287.43,39.66 286.7,40.4 286.7,42.2 287.05,42.56 290.97,42.56
GND on BOTTOM (solid shape): 187.23,126.55 187.23,125.54 186.93,125.23 185.25,125.23 182.89,122.87 181.01,122.87 180.27,123.61 180.27,126.1 180.85,126.67 187.12,126.67
GND on BOTTOM (solid shape): 313.8,64.63 313.8,62.22 313.14,61.56 312.17,61.56 311.89,61.84 311.89,64.38 312.28,64.76 313.67,64.76
GND on BOTTOM (solid shape): 103.08,72.96 103.08,69.2 102.9,69.02 101.66,69.02 101.25,69.43 101.25,70.37 101,70.62 98.36,70.62 98.15,70.83 98.15,73.01 98.38,73.24 102.8,73.24
GND on BOTTOM (solid shape): 130.03,118.3 130.03,115.94 129.83,115.73 126.82,115.73 126.66,115.89 126.66,116.6 126.49,116.78 126.49,118.44 126.6,118.55 129.78,118.55
GND on BOTTOM (solid shape): 143.04,117.95 143.04,116.95 143.11,116.88 143.11,115.73 142.98,115.61 139.91,115.61 139.73,115.78 139.73,118.15 139.95,118.36 142.63,118.36
GND on BOTTOM (solid shape): 206.89,71.79 206.89,70.17 206.15,69.43 202.27,69.43 202.12,69.28 197.34,69.28 197.01,69.61 197.01,70.75 197.19,70.93 200.36,70.93 202.85,73.42 205.27,73.42
GND on BOTTOM (solid shape): 308.75,65.09 308.75,63.74 308.36,63.36 305.16,63.36 304.53,63.99 304.53,65.01 304.65,65.13 305.99,65.13 305.99,65.14 306.74,65.14 306.92,65.31 308.52,65.31
GND on BOTTOM (solid shape): 273.11,40.65 273.11,39.79 272.83,39.51 270.11,39.51 270.1,39.5 269.11,39.5 268.59,38.98 267.19,38.98 266.78,39.38 266.78,40.47 267.06,40.75 273.01,40.75
GND on BOTTOM (solid shape): 201.33,61.56 201.33,58.48 200.49,57.64 197.06,57.64 196.52,58.18 196.52,61.6 196.63,61.71 201.18,61.71
GND on BOTTOM (solid shape): 291.17,49.41 291.17,46.65 290.89,46.37 290.58,46.37 290.23,46.72 288.98,46.72 288.78,46.93 288.78,48.32 288.45,48.65 288.2,48.65 288.02,48.83 288.02,49.11 288.7,49.79 290.79,49.79
GND on BOTTOM (solid shape): 303.02,67.31 303.02,67.11 302.29,66.38 302.29,65.95 301.73,65.39 301.73,64.12 300.97,63.36 299.83,63.36 299.45,63.74 299.45,65.2 299.61,65.46 299.77,65.71 300.85,66.79 300.85,66.92 301.99,68.06 302.27,68.06
GND on BOTTOM (solid shape): 167.5,124.57 167.5,118.81 167.32,118.63 165.92,118.63 165.72,118.83 165.72,118.96 165.73,119.08 165.72,119.19 165.72,123.73 165.51,123.94 165.51,124.57 165.69,124.75 167.32,124.75
GND on BOTTOM (solid shape): 206.71,115.86 206.71,113.98 206.55,113.82 206.55,113.59 206.54,113.57 206.54,107.99 206.31,107.76 204.96,107.76 204.81,107.91 204.81,112 204.43,112.38 204.43,113.19 204.55,113.32 204.55,115.86 204.76,116.06 206.51,116.06
GND on BOTTOM (solid shape): 124.01,125.77 124.01,125.06 123.81,124.85 123.81,116.04 123.63,115.86 119.21,115.86 118.63,116.45 118.63,118.15 118.7,118.22 120.81,118.22 120.9,118.13 121.48,118.13 121.62,118.28 121.62,123.13 121.52,123.23 121.52,124.95 121.47,125 121.47,125.61 121.78,125.92 123.86,125.92
GND on BOTTOM (solid shape): 288.6,31.38 288.6,27.37 286.27,25.03 285.43,25.03 285,25.46 285,27.62 285.2,27.82 286.8,27.82 287.14,28.17 287.14,29.62 286.88,29.88 286.67,29.88 286.6,29.96 286.6,31.66 286.88,31.94 288.04,31.94
GND on BOTTOM (solid shape): 144.3,27.3 144.29,27.27 144.32,27 144.52,26.82 144.56,26.8 144.56,25.78 144.47,25.69 144.47,25.1 143.9,24.53 141.36,24.53 140.22,25.67 140.22,27.33 140.6,27.71 143.9,27.71
GND on BOTTOM (solid shape): 228.41,52.77 228.41,49.63 228.55,49.48 229.15,49.48 229.34,49.29 229.34,47.92 229.14,47.71 216.9,47.71 216.8,47.81 216.8,49.52 217,49.72 223.48,49.72 223.73,49.97 223.73,51.43 224.07,51.77 224.07,52.93 224.21,53.07 228.1,53.07
GND on BOTTOM (solid shape): 199.3,123.2 204.05,123.2 204.22,123.02 204.22,120.53 200.85,117.16 199.63,117.16 199.4,117.39 199.4,120.58 198.24,121.74 197.51,121.74 197.34,121.91 197.34,122.77 197.24,122.87 197.24,123.35 197.32,123.43 199.07,123.43
GND on BOTTOM (solid shape): 154.19,24.78 154.19,22.36 153.68,21.86 153.68,21.86 153.32,21.5 153.32,20.86 153.02,20.56 150.5,20.56 150.43,20.64 150.43,21.02 150.6,21.2 150.99,21.2 151.24,21.45 151.24,22.03 151.34,22.13 152.1,22.13 152.48,22.52 152.48,23.85 152.12,24.22 152.12,24.81 152.26,24.95 154.01,24.95
GND on BOTTOM (solid shape): 136.79,24.61 136.79,24.13 136.59,23.92 136.59,23.61 136.18,23.2 136.18,22.74 136.57,22.36 137.2,22.36 137.27,22.29 137.27,20.04 137.12,19.88 132.89,19.88 132.57,20.2 132.11,20.2 131.53,20.79 131.53,21.83 132.79,23.1 132.8,23.1 133.46,23.76 135.73,23.76 135.88,23.91 135.88,24.66 135.9,24.68 136.71,24.68
GND on BOTTOM (solid shape): 207.53,30.19 207.53,29.04 207.32,28.84 206.68,28.84 206.54,28.7 206.54,27.32 206.07,27.32 206.07,28.59 206.04,28.62 205.61,28.62 205.57,28.58 205.57,27.33 205.56,27.32 205.07,27.32 205.07,28.66 204.76,28.97 204.76,29.32 204.86,29.42 206.69,29.42 206.99,29.73 206.99,30.21 207.12,30.34 207.37,30.34
GND on BOTTOM (solid shape): 16.92,85.79 16.92,84.82 17.13,84.62 17.13,83.93 17.39,83.67 17.39,83.16 18.52,82.03 18.52,81.14 18.4,81.01 18.27,81.01 17.76,81.52 16.62,81.52 16.49,81.65 16.49,82.33 16.16,82.66 15.15,82.66 14.99,82.82 14.99,83.07 15.53,83.6 15.53,84.77 15.65,84.9 15.65,85.74 15.88,85.97 16.75,85.97
GND on BOTTOM (solid shape): 37.11,40.53 37.11,37.21 37.63,36.69 37.63,35.16 36.84,34.36 36.47,34.36 36.15,34.05 36.15,33.01 36.1,32.96 34.22,32.96 33.88,33.3 33.88,36.19 34.99,37.3 34.99,39.34 34.86,39.47 34.65,39.47 34.22,39.89 34.22,41.23 34.46,41.46 36.18,41.46
GND on BOTTOM (solid shape): 207.02,50.99 207.02,48.12 207.03,48.11 207.03,47.8 207.12,47.71 208.26,47.71 208.49,47.94 214.49,47.94 214.59,47.84 214.59,47.2 213.32,45.93 213.32,42.73 212.94,42.35 209.99,42.35 209.74,42.61 209.74,45.4 208.62,46.52 202.52,46.52 201.65,47.4 201.65,49.25 202.19,49.8 202.98,49.8 203.11,49.92 203.27,49.92 203.43,50.09 203.43,50.91 203.62,51.09 206.91,51.09
GND on BOTTOM (solid shape): 129.62,23.18 129.62,21.45 129.55,21.37 125.97,21.37 125.6,21.74 121.86,21.74 121.72,21.89 120.92,21.89 120.76,22.04 120.76,23.38 120.18,23.96 120.18,24.62 119.97,24.83 119.97,25.39 118.91,26.45 117.9,26.45 117.89,26.45 117.43,26.91 117.43,29.86 117.64,30.06 122.74,30.06
GND on BOTTOM (solid shape): 174.56,47.48 174.56,43.95 174.25,43.65 174.1,43.65 173.52,43.06 173.24,43.06 173.03,43.27 173.03,43.8 174.23,43.8 174.23,45.81 173.97,45.81 173.97,43.8 173.62,43.8 173.62,45.81 173.39,45.81 173.39,43.8 173.03,43.8 173.03,45.78 173.06,45.81 173.06,47.53 173.52,47.99 174.05,47.99
GND on BOTTOM (solid shape): 301.1,62.98 301.35,62.88 301.6,62.98 301.74,62.98 301.99,62.88 302.24,62.98 305.16,62.98 305.67,62.47 305.67,60.69 305.29,60.31 301.23,60.31 300.59,60.95 300.59,62.8 300.77,62.98
GND on BOTTOM (solid shape): 32.37,17.99 32.37,12.56 32.22,12.41 31.71,12.41 31.45,12.66 31.45,13.27 31.25,13.47 30.5,13.47 30.42,13.55 30.39,13.64 30.43,13.71 30.58,14.07 30.31,14.36 30.27,14.36 30.27,15.13 29.97,15.43 29.87,15.43 29.87,15.45 28.88,15.45 28.88,15.43 27.56,15.43 27.09,15.9 27.09,17.77 27.43,18.11 32.25,18.11
GND on BOTTOM (solid shape): 26.37,62.85 26.4,62.85 26.4,62.19 26.68,61.91 27.49,61.91 27.54,61.86 27.54,60.87 27.21,60.54 26.04,60.54 25.74,60.23 24.11,60.23 24.04,60.31 24.04,61.12 24.16,61.25 24.16,63.28 24.29,63.41 24.62,63.73 24.37,64.11 24.27,64.12 24.16,64.11 23.95,64.11 23.6,64.45 23.6,64.71 23.78,64.88 24.34,64.88
GND on BOTTOM (solid shape): 151.14,107.05 151.14,106.34 151.12,106.26 151.11,106.19 151.11,105.88 151.13,105.78 151.16,105.67 151.16,105.38 151.13,105.28 151.11,105.17 151.11,105.11 150.89,104.89 150.68,104.89 150.58,104.79 149.81,104.79 149.49,105.11 149.49,105.17 149.48,105.28 149.44,105.39 149.44,105.67 149.48,105.77 149.49,105.88 149.49,106.19 149.48,106.3 149.44,106.4 149.44,107.02 149.64,107.22 150.96,107.22
GND on BOTTOM (solid shape): 155.79,124.01 155.41,123.63 151.62,123.63 150.91,122.92 148.29,122.92 148.26,122.9 147.91,122.54 147.91,118.98 148.01,118.88 148.01,117.16 148.19,116.98 148.98,116.98 149.16,116.8 149.16,115.53 148.67,115.05 145.25,115.05 144.74,114.54 143.87,114.54 143.62,114.79 143.62,115.43 143.87,115.68 144.28,115.68 144.66,116.06 144.66,116.72 144.95,117.01 145,117.03 145.25,117.03 145.29,117.03 145.6,117.03 145.73,117.16 145.73,118.88 145.83,118.98 145.83,122.93 145.75,123.01 145.75,123.05 145.75,123.1 145.73,123.15 145.73,123.2 145.74,123.25 145.75,123.29 145.75,123.38 145.75,124.43 146,124.68 147.26,124.68 147.53,124.95 147.53,126.4 147.8,126.67 155.79,126.67
GND on BOTTOM (solid shape): 15.47,70.73 15.47,65.61 15.14,65.27 13.22,65.27 13,65.05 13,64.36 12.95,64.27 12.84,64.28 12.5,64.4 12.14,64.32 12.04,64.33 11.99,64.42 11.99,65.72 12,65.75 12.01,65.76 12.18,66.59 11.48,67.06 2.51,67.06 2.51,70.14 8.67,70.14 9.17,69.64 12.39,69.64 12.39,71.87 12.76,72.24 13.97,72.24
GND on BOTTOM (solid shape): 318.59,42.12 322.14,42.12 322.14,41.78 322.44,41.06 323.15,40.77 325.05,40.77 325.76,41.06 326.06,41.78 326.06,42.12 328.99,42.12 328.99,40.14 328.29,40.14 328.29,38.73 328.18,38.62 326.96,38.62 325.82,39.75 323.15,39.75 321.98,40.12 321.24,41.1 317.87,41.1 317.58,41.4 317.58,43.04 318.59,43.04
GND on BOTTOM (solid shape): outline of 81 points within 163.69,16.73 176.61,27.72
GND on BOTTOM (solid shape): outline of 97 points within 224.14,71.87 227.62,78.29
GND on BOTTOM (solid shape): 318.01,64.32 318.01,63.66 317.81,62.83 318.52,62.34 328.29,62.34 328.29,59.42 328.99,59.42 328.99,57.43 326.06,57.43 326.06,57.78 325.76,58.49 325.05,58.78 323.15,58.78 322.44,58.49 322.14,57.78 322.14,57.43 319.51,57.43 318.87,58.07 318.87,58.39 318.93,58.45 321.24,58.45 321.98,59.43 323.15,59.8 325.03,59.8 325.53,60.31 325.53,60.82 325.03,61.33 318.52,61.33 318.22,61.02 314.87,61.02 314.64,61.25 314.64,62.57 316.54,64.48 317.86,64.48
GND on BOTTOM (solid shape): 315.64,26.38 315.9,26.38 316.3,25.97 328.29,25.97 328.29,18.7 328.15,18.35 327.8,18.21 318.75,18.21 318.4,18.35 318.26,18.7 318.26,23.1 317.82,24.17 316.75,24.61 312.75,24.61 311.68,24.17 311.24,23.1 311.24,22.1 311.1,21.75 310.75,21.61 303.32,21.61 303.22,21.69 303.28,21.8 303.8,22.14 304.17,22.62 310.23,22.62 310.23,23.1 310.85,24.76 312.42,25.6 313.19,26.38 315.64,26.38
GND on BOTTOM (solid shape): outline of 87 points within 0.51,81.71 26.44,110.89
GND on BOTTOM (solid shape): 267.35,22.57 267.82,21.96 268.53,22.25 268.62,22.3 268.71,22.25 269.42,21.96 269.89,22.57 269.89,22.62 271.16,22.62 271.16,22.57 271.63,21.96 272.34,22.25 272.43,22.3 272.52,22.25 273.23,21.96 273.7,22.57 273.7,22.62 280.05,22.62 280.05,22.57 280.52,21.96 281.23,22.25 281.32,22.3 281.95,21.93 282.59,22.3 282.68,22.25 283.28,21.94 283.82,22.34 284.1,22.62 287.47,22.62 287.69,22.4 287.97,22.03 288.43,21.95 288.48,21.96 288.48,21.93 290.87,21.93 290.89,21.94 291.24,22.07 291.45,22.39 291.69,22.62 292.62,22.62 292.75,22.49 293.32,21.94 293.99,22.37 294.24,22.62 295.1,22.62 295.31,22.42 295.83,21.94 296.47,22.25 296.56,22.3 297.19,21.93 297.83,22.3 297.92,22.25 298.63,21.96 299.1,22.57 299.1,22.62 299.38,22.62 299.43,22.26 299.62,21.94 299.62,21.61 265.43,21.61 265.43,21.82 265.73,22.17 265.81,22.62 267.35,22.62
GND on BOTTOM (solid shape): outline of 384 points within 2.51,48.81 32.71,61.33
GND on BOTTOM (solid shape): outline of 257 points within 125.25,97.8 146.95,102.49
GND on BOTTOM (solid shape): outline of 562 points within 2.51,0.51 261.97,27.72
GND on BOTTOM (solid shape): outline of 1116 points within 23.12,49.38 328.29,128.19
GND on BOTTOM (solid shape): outline of 10271 points within 120.91,77.53 156.09,97.07
GND on SGND (solid shape): outline of 3814 points within 0.51,0.51 328.99,128.19
GND on IN1 (solid shape): 291.77,41.76 291.77,40.73 290.7,39.66 287.31,39.66 286.7,40.27 286.7,42.2 287.05,42.56 290.97,42.56
GND on IN1 (solid shape): 143.75,108.84 143.75,108.03 143.53,107.81 143.53,106.17 143.35,105.99 140.94,105.99 140.9,105.95 140.05,105.95 139.96,106.04 139.96,108.33 140.57,108.93 143.66,108.93
GND on IN1 (solid shape): 192.91,79.39 192.91,79.22 192.32,78.64 192.32,76.21 192.12,76.01 189.2,76.01 189.12,75.92 189.12,75.49 189,75.37 188.72,75.37 188.55,75.55 188.55,78.77 188.73,78.95 191.85,78.95 192.43,79.54 192.76,79.54
GND on IN1 (solid shape): 318.59,42.12 322.14,42.12 322.14,41.78 322.44,41.06 323.15,40.77 325.05,40.77 325.76,41.06 326.06,41.78 326.06,42.12 328.99,42.12 328.99,40.14 328.29,40.14 328.29,38.84 328.13,38.67 326.57,38.67 325.45,39.79 325.25,39.76 325.05,39.75 323.15,39.75 321.98,40.12 321.24,41.1 317.58,41.1 317.58,43.03 318.59,43.03
GND on IN1 (solid shape): 13.34,72.62 13.4,72.52 13.68,72.52 15.47,70.73 15.47,65.9 14.86,65.29 13,65.29 13,64.36 12.95,64.27 12.84,64.28 12.5,64.4 12.14,64.32 12.04,64.33 11.99,64.41 11.99,65.72 12,65.75 12.01,65.76 12.18,66.59 11.48,67.06 2.51,67.06 2.51,70.14 8.67,70.14 9.17,69.64 12.39,69.64 12.39,72.39 12.44,72.48 12.54,72.48 12.9,72.42 13.23,72.59
GND on IN1 (solid shape): 318.01,63.66 317.81,62.83 318.52,62.34 328.29,62.34 328.29,59.42 328.99,59.42 328.99,57.43 326.06,57.43 326.06,57.78 325.76,58.49 325.05,58.78 323.15,58.78 322.44,58.49 322.14,57.78 322.14,57.43 319.51,57.43 318.9,58.05 318.9,58.45 318.9,58.45 321.24,58.45 321.98,59.43 323.15,59.8 325.05,59.8 326.22,59.43 326.96,58.45 327.28,58.45 327.28,61.33 318.88,61.33 318.84,61.29 317.24,61.29 316.75,60.79 315.04,60.79 314.61,61.23 314.61,63.49 315.91,64.78 318.01,64.78
GND on IN1 (solid shape): 328.29,18.7 328.15,18.35 327.8,18.21 318.75,18.21 318.4,18.35 318.26,18.7 318.26,23.1 317.82,24.17 316.75,24.61 312.75,24.61 311.68,24.17 311.24,23.1 311.24,22.1 311.1,21.75 310.75,21.61 303.32,21.61 303.22,21.69 303.28,21.8 303.8,22.14 304.17,22.62 310.23,22.62 310.23,23.1 310.97,24.88 312.75,25.62 316.75,25.62 317.52,25.5 318.21,25.16 325.88,25.16 326.7,25.97 328.29,25.97
GND on IN1 (solid shape): 267.35,22.57 267.82,21.96 268.53,22.25 268.62,22.3 268.71,22.25 269.42,21.96 269.89,22.57 269.89,22.62 271.16,22.62 271.16,22.57 271.63,21.96 272.34,22.25 272.43,22.3 272.52,22.25 273.23,21.96 273.7,22.57 273.7,22.62 280.05,22.62 280.05,22.57 280.52,21.96 281.23,22.25 281.32,22.3 281.95,21.93 282.59,22.3 282.68,22.25 283.39,21.96 283.86,22.57 283.86,22.62 287.67,22.62 287.67,22.57 288.14,21.96 288.85,22.25 288.94,22.3 289.57,21.93 290.21,22.3 290.3,22.25 291.01,21.96 291.48,22.57 291.48,22.62 292.75,22.62 292.75,22.57 293.38,21.93 294.02,22.57 294.02,22.62 295.29,22.62 295.29,22.57 295.76,21.96 296.47,22.25 296.56,22.3 297.19,21.93 297.83,22.3 297.92,22.25 298.63,21.96 299.1,22.57 299.1,22.59 299.33,22.59 299.33,21.61 266,21.61 266,22.62 267.35,22.62
GND on IN1 (solid shape): outline of 150 points within 2.51,0.51 261.97,55.21
GND on IN1 (solid shape): outline of 401 points within 0.51,49.38 328.29,128.19
GND on SVCC (solid shape): outline of 1200 points within 45.96,31.66 225.22,126.67
GND on IN2 (solid shape): 291.77,41.76 291.77,40.35 291.08,39.66 287.31,39.66 286.7,40.27 286.7,42.2 287.05,42.56 290.97,42.56
GND on IN2 (solid shape): 167.04,74.15 167.04,72.32 166.83,72.11 163.89,72.11 163.71,72.28 163.71,73.98 163.91,74.19 163.91,74.42 164.05,74.55 166.63,74.55
GND on IN2 (solid shape): 192.96,79.39 192.96,79.24 192.32,78.61 192.32,76.21 192.22,76.1 190.38,76.1 190.28,76.01 189.2,76.01 189.13,75.93 189.13,75.52 188.98,75.37 188.72,75.37 188.55,75.55 188.55,78.77 188.73,78.95 191.98,78.95 192.57,79.55 192.81,79.55
GND on IN2 (solid shape): 113.84,118.16 113.87,118.12 113.9,118.08 113.9,116.92 113.89,116.83 113.9,116.73 113.9,113.91 113.52,113.52 113.33,113.52 113.04,113.66 112.75,113.52 108.82,113.52 108.44,113.91 108.44,116.25 108.53,116.5 108.44,116.74 108.44,118.35 108.69,118.6 113.39,118.6
GND on IN2 (solid shape): 15.27,71.49 15.27,66.38 14.64,65.75 13.16,65.75 13.09,65.57 13,65.39 13,64.38 12.95,64.29 12.85,64.29 12.5,64.41 12.13,64.34 12.04,64.34 11.99,64.43 11.99,65.72 12,65.75 12.01,65.76 12.18,66.59 11.48,67.06 2.51,67.06 2.51,70.14 8.67,70.14 9.15,69.66 12.39,69.66 12.39,71.55 12.8,71.96 14.8,71.96
GND on IN2 (solid shape): 318.59,42.12 322.14,42.12 322.14,41.78 322.44,41.06 323.15,40.77 325.05,40.77 325.76,41.06 326.06,41.78 326.06,42.12 328.99,42.12 328.99,40.14 328.29,40.14 328.29,38.92 328.01,38.64 326.5,38.64 325.37,39.78 325.21,39.76 325.05,39.75 323.15,39.75 321.98,40.12 321.24,41.1 317.58,41.1 317.58,43.03 318.59,43.03
GND on IN2 (solid shape): 318.01,63.66 317.81,62.83 318.52,62.34 328.29,62.34 328.29,59.42 328.99,59.42 328.99,57.43 326.06,57.43 326.06,57.78 325.76,58.49 325.05,58.78 323.15,58.78 322.44,58.49 322.14,57.78 322.14,57.43 319.5,57.43 318.87,58.07 318.87,58.4 318.92,58.45 321.24,58.45 321.98,59.43 323.15,59.8 325.05,59.8 326.22,59.43 326.96,58.45 327.28,58.45 327.28,61.33 318.63,61.33 318.24,60.95 315.1,60.95 314.46,61.58 314.46,63 316.26,64.81 318.01,64.81
GND on IN2 (solid shape): 328.29,18.7 328.15,18.35 327.8,18.21 318.75,18.21 318.4,18.35 318.26,18.7 318.26,23.1 317.82,24.17 316.75,24.61 312.75,24.61 311.68,24.17 311.24,23.1 311.24,22.1 311.1,21.75 310.75,21.61 303.35,21.61 303.25,21.69 303.31,21.8 303.82,22.14 304.18,22.62 310.23,22.62 310.23,23.1 310.97,24.88 312.75,25.62 316.75,25.62 317.1,25.97 328.29,25.97
GND on IN2 (solid shape): 267.34,22.57 267.8,21.95 268.53,22.22 268.62,22.27 268.71,22.22 269.44,21.95 269.9,22.57 269.9,22.62 271.15,22.62 271.15,22.57 271.61,21.95 272.34,22.22 272.43,22.27 272.52,22.22 273.25,21.95 273.71,22.57 273.71,22.62 280.04,22.62 280.04,22.57 280.5,21.95 281.23,22.22 281.32,22.27 281.95,21.92 282.59,22.27 282.68,22.22 283.41,21.95 283.87,22.57 283.87,22.62 287.66,22.62 287.66,22.57 288.12,21.95 288.85,22.22 288.94,22.27 289.57,21.92 290.21,22.27 290.3,22.22 291.03,21.95 291.49,22.57 291.49,22.62 292.74,22.62 292.74,22.57 293.38,21.92 294.03,22.57 294.03,22.62 295.28,22.62 295.28,22.57 295.74,21.95 296.47,22.22 296.56,22.27 297.19,21.92 297.83,22.27 297.92,22.22 298.65,21.95 299.11,22.57 299.11,22.62 299.38,22.62 299.45,22.21 299.69,21.87 299.69,21.61 265.92,21.61 265.92,22.62 267.34,22.62
GND on IN2 (solid shape): outline of 145 points within 2.51,0.51 261.94,55.11
GND on IN2 (solid shape): outline of 361 points within 0.51,49.38 328.29,128.19
GND on IN3 (solid shape): 291.77,41.76 291.77,40.35 291.08,39.66 287.31,39.66 286.7,40.27 286.7,42.2 287.05,42.56 290.97,42.56
GND on IN3 (solid shape): 143.72,108.83 143.72,107.4 143.57,107.25 143.57,106.09 143.43,105.95 140.05,105.95 139.96,106.04 139.96,108.84 140.08,108.95 143.59,108.95
GND on IN3 (solid shape): 167.04,74.15 167.04,72.32 166.83,72.11 163.89,72.11 163.71,72.28 163.71,73.98 163.92,74.18 163.92,74.43 164.05,74.55 166.63,74.55
GND on IN3 (solid shape): 192.95,79.44 192.95,79.24 192.32,78.61 192.32,76.21 192.12,76.01 189.2,76.01 189.1,75.9 189.1,75.48 188.99,75.37 188.72,75.37 188.55,75.55 188.55,78.77 188.73,78.95 191.89,78.95 192.5,79.57 192.82,79.57
GND on IN3 (solid shape): 318.59,42.12 322.14,42.12 322.14,41.78 322.44,41.06 323.15,40.77 325.05,40.77 325.76,41.06 326.06,41.78 326.06,42.12 328.99,42.12 328.99,40.14 328.29,40.14 328.29,38.98 327.96,38.64 325.91,38.64 324.8,39.75 323.15,39.75 321.98,40.12 321.24,41.1 317.58,41.1 317.58,43.03 318.59,43.03
GND on IN3 (solid shape): 13.4,72.75 13.49,72.72 15.15,71.06 15.15,68.69 15.47,68.36 15.47,66.13 14.99,65.65 13.13,65.65 13.07,65.52 13,65.39 13,64.38 12.95,64.29 12.85,64.29 12.5,64.41 12.13,64.34 12.04,64.34 11.99,64.43 11.99,65.72 12,65.75 12.01,65.76 12.18,66.59 11.48,67.06 2.51,67.06 2.51,70.14 8.67,70.14 9.17,69.64 12.39,69.64 12.39,72.38 12.44,72.47 12.54,72.47 12.98,72.43 13.33,72.7
GND on IN3 (solid shape): 318.01,63.66 317.81,62.83 318.52,62.34 328.29,62.34 328.29,59.42 328.99,59.42 328.99,57.43 326.06,57.43 326.06,57.78 325.76,58.49 325.05,58.78 323.15,58.78 322.44,58.49 322.14,57.78 322.14,57.43 319.51,57.43 318.86,58.09 318.86,58.45 321.24,58.45 321.98,59.43 323.15,59.8 325.05,59.8 326.22,59.43 326.96,58.45 327.28,58.45 327.28,61.33 318.83,61.33 318.6,61.1 315.04,61.1 314.77,61.38 314.77,63.33 316.37,64.93 318.01,64.93
GND on IN3 (solid shape): 328.29,18.7 328.15,18.35 327.8,18.21 318.75,18.21 318.4,18.35 318.26,18.7 318.26,23.1 317.82,24.17 316.75,24.61 312.75,24.61 311.68,24.17 311.24,23.1 311.24,22.1 311.1,21.75 310.75,21.61 303.35,21.61 303.25,21.69 303.31,21.8 303.82,22.14 304.18,22.62 310.23,22.62 310.23,23.1 310.97,24.88 312.75,25.62 316.75,25.62 317.22,25.58 317.68,25.45 318.05,25.45 318.58,25.98 328.29,25.98
GND on IN3 (solid shape): 267.34,22.57 267.8,21.95 268.53,22.22 268.62,22.27 268.71,22.22 269.44,21.95 269.9,22.57 269.9,22.62 271.15,22.62 271.15,22.57 271.61,21.95 272.34,22.22 272.43,22.27 272.52,22.22 273.25,21.95 273.71,22.57 273.71,22.62 279.99,22.62 280.02,22.61 280.04,22.57 280.5,21.95 281.23,22.22 281.32,22.27 281.95,21.92 282.59,22.27 282.68,22.22 283.41,21.95 283.87,22.57 283.89,22.61 283.92,22.62 287.61,22.62 287.64,22.61 287.66,22.57 288.12,21.95 288.85,22.22 288.94,22.27 289.57,21.92 290.21,22.27 290.3,22.22 291.03,21.95 291.49,22.57 291.51,22.61 291.54,22.62 292.69,22.62 292.72,22.61 292.74,22.57 293.38,21.92 294.03,22.57 294.05,22.61 294.08,22.62 295.23,22.62 295.26,22.61 295.28,22.57 295.74,21.95 296.47,22.22 296.56,22.27 297.19,21.92 297.83,22.27 297.92,22.22 298.65,21.95 299.11,22.57 299.13,22.61 299.16,22.62 299.38,22.62 299.46,22.17 299.76,21.82 299.76,21.61 265.84,21.61 265.69,21.76 265.69,22.11 265.79,22.36 265.81,22.62 267.34,22.62
GND on IN3 (solid shape): outline of 1061 points within 2.51,0.51 260.79,55.13
GND on IN3 (solid shape): outline of 405 points within 0.51,49.38 328.29,128.19
GND on SGND1 (solid shape): outline of 3890 points within 0.51,0.51 328.99,128.19
VDD10 on TOP (solid shape): 283.95,48.35 283.95,47.74 284.06,47.64 285.15,47.64 285.33,47.46 285.33,47 285.15,46.82 282.3,46.82 282.13,47 282.13,47.81 282.81,48.5 283.8,48.5
VDD10 on BOTTOM (solid shape): 288.16,53.44 288.32,53.4 288.48,53.44 288.49,53.44 291.64,53.44 292.21,52.87 292.21,50.41 292.62,50 292.79,50 293.18,49.62 293.18,46.65 292.57,46.04 291.55,46.04 291.37,46.21 291.37,49.69 291.38,49.71 291.19,49.9 291.19,51.27 291.25,51.32 291.25,51.62 291.04,51.83 290.74,51.83 290.59,51.68 289.12,51.68 288.73,51.93 288.34,51.68 288.27,51.68 287.51,50.91 285.99,50.91 284.97,49.9 284.21,49.9 284.08,49.77 284.08,48.5 284.72,47.87 285.02,47.87 285.43,47.46 285.86,47.46 286.16,47.15 286.16,46.9 285.94,46.67 285.66,46.67 284.69,45.71 282.2,45.71 281.54,46.37 281.54,49.01 283.32,50.79 283.83,50.79 285.1,52.06 286.75,52.06 288.13,53.44
8207DRVH on BOTTOM (solid shape): 158.38,19.4 158.38,18.44 158.25,18.31 157.13,18.31 156.98,18.46 156.98,19.4 157.11,19.52 158.25,19.52
8207DRVL on TOP (solid shape): 171.69,25.89 171.69,25.13 171.56,25.01 170.29,25.01 170.16,25.13 170.16,25.89 170.29,26.02 171.56,26.02
8207DRVL on BOTTOM (solid shape): 166.38,17.67 166.38,17.17 166.13,16.91 164.35,16.91 164.22,17.04 164.22,17.65 164.25,17.67 165.29,17.67 165.54,17.93 166.13,17.93
8207LX on BOTTOM (solid shape): 163.97,23.39 163.97,22.37 163.3,21.71 163.3,16.88 163.14,16.72 159.08,16.72 158.76,17.04 158.76,19.4 158.3,19.87 157.14,19.87 156.96,20.05 156.96,24.05 157.19,24.28 163.08,24.28
81172_PH1 on BOTTOM (solid shape): 211.96,58.49 211.96,55.78 211.76,55.59 207.96,55.59 207.27,54.9 207.27,52.51 206.81,52.05 201.97,52.05 201.35,52.66 201.35,52.69 201.18,52.87 200.24,52.87 200.11,53 200.11,56.93 201.53,58.36 201.53,60.68 202.22,61.37 209.09,61.37
81172_PH2 on BOTTOM (solid shape): 225.42,67.14 225.76,66.86 226.11,67.14 227.29,67.14 227.74,66.69 227.74,57.52 229.34,55.92 229.34,53.5 229.24,53.4 228.17,53.4 227.55,54.03 221.4,54.03 221.24,53.87 220.45,53.87 220.24,54.08 220.24,66.77 220.61,67.14
81172GND on IN1 (solid shape): outline of 195 points within 233.15,48.93 240.39,58.03
+CARD_3V3 on TOP (solid shape): 61.37,38.7 61.37,37.98 61.17,37.78 60.37,37.78 60.35,37.79 59.43,37.79 59.39,37.83 59.39,37.97 60.36,37.97 60.51,38.12 60.51,38.47 60.94,38.9 61.17,38.9
+CARD_3V3 on TOP (solid shape): 34.04,38.19 35.14,38.19 35.29,38.04 35.29,37.07 34.48,36.26 34.24,36.26 33.87,36.63 33.87,36.64 33.38,36.64 33.28,36.74 33.28,38.44 33.38,38.54 33.69,38.54
+CARD_3V3 on BOTTOM (solid shape): 33.69,38.44 33.69,38.29 33.89,38.09 34.7,38.09 34.81,37.98 34.81,37.5 33.97,36.66 33.28,36.66 33.05,36.44 32.11,36.44 32.06,36.49 32.06,38.04 32.14,38.11 32.98,38.11 33.35,38.48 33.65,38.48
+CARD_3V3 on IN3 (solid shape): 35.85,38.37 35.85,37.6 35.58,37.34 35.1,37.34 34.45,36.69 33.33,36.69 33.26,36.77 33.26,38.67 33.33,38.75 35.47,38.75
+CARD_3V3 on IN3 (solid shape): outline of 159 points within 60.36,37.76 63.71,40.85
+DC_IN on TOP (solid shape): 20.73,92.41 20.73,90.93 20.55,90.76 17.56,90.76 17.51,90.81 17.51,92.5 17.61,92.59 20.54,92.59
+DC_IN on BOTTOM (solid shape): 23,92.99 23,91.45 22.92,91.37 19.61,91.37 19.61,91.37 19.48,91.37 19.42,91.31 19.42,90.05 19.79,89.67 19.79,88.76 19.67,88.63 17.51,88.63 17.34,88.8 17.34,91.17 17.62,91.45 17.62,93.2 17.64,93.22 22.77,93.22
+DC_IN_SS on BOTTOM (solid shape): outline of 610 points within 15.88,59.9 33.53,88.38
+DCIN_JACK on TOP (solid shape): 17.76,96.13 17.76,92.95 17.51,92.7 12.43,92.7 12.17,92.95 12.17,96.38 12.43,96.63 17.25,96.63
+DCIN_JACK on BOTTOM (solid shape): 17.24,95.87 17.24,91.61 17.14,91.51 15.77,91.51 14.97,92.32 12.17,92.32 12.09,92.4 12.09,95.79 12.56,96.25 16.86,96.25
+DCPSUSBYP on TOP (solid shape): outline of 763 points within 143.21,77.3 149.51,87.74
+DDR_VTT on TOP (solid shape): 174.9,25.56 176.56,25.56 176.68,25.67 178.19,25.67 178.45,25.42 180.1,25.42 180.48,25.04 180.48,23.9 180.27,23.69 176.61,23.69 176.43,23.87 176,23.87 175.92,23.95 175.47,23.95 175.13,24.29 174.74,24.29 173.95,25.08 173.95,26.05 173.99,26.08 174.38,26.08
+DDR_VTT on TOP (solid shape): 180.96,45.43 180.96,43.29 180.86,43.04 180.96,42.79 180.96,41.9 180.75,41.69 180.25,41.69 179.69,41.13 179.69,39.99 180.96,38.72 180.96,34.83 180.72,34.59 179.62,34.59 179.54,34.68 179.54,37.98 178.54,38.98 178.54,42.02 179.08,42.56 179.64,42.56 179.84,42.76 179.84,44.33 179.08,45.1 179.08,45.43 179.38,45.73 180.65,45.73
+DDR_VTT on BOTTOM (solid shape): 180.35,45.2 180.35,44.06 180.07,43.78 178.79,43.78 178.77,43.78 178.76,43.79 178.53,43.79 178.44,43.88 178.44,45.93 178.49,45.99 179.56,45.99
+DDR_VTT on BOTTOM (solid shape): outline of 407 points within 174.48,23.72 181.14,39.03
+FB_PLLAVDD on TOP (solid shape): 204.66,106.11 204.28,105.73 203.21,105.73 203.03,105.9 203.03,106.46 203.61,107.05 203.61,107.66 203.82,107.86 204.66,107.86
+FB_PLLAVDD on TOP (solid shape): 199.91,94.33 199.91,94.12 199.42,93.64 199.42,93.48 199.37,93.43 198.94,93.43 198.88,93.5 198.88,94.11 199.31,94.54 199.7,94.54
+FB_PLLAVDD on IN2 (solid shape): outline of 1164 points within 195.31,87.44 204.35,107.56
+LCDVCC on TOP (solid shape): 275.09,42.28 275.09,38.09 274.76,37.76 272.25,37.76 271.81,38.19 271.81,38.42 272.22,38.82 273.44,38.82 273.44,40.35 273.82,40.73 273.82,42.05 274.15,42.38 274.99,42.38
+LCDVCC on BOTTOM (solid shape): 272.09,33.67 272.09,32.09 272.02,32.02 271.89,32.02 271.86,32.04 271.86,33.16 271.84,33.18 271.64,33.18 271.61,33.16 271.61,32.04 271.59,32.02 271.15,32.02 270.92,32.24 270.92,32.57 270.32,33.18 270.32,33.69 270.44,33.82 271.03,33.82 271.1,33.9 271.86,33.9
+LCDVCC on IN2 (solid shape): outline of 140 points within 268.84,33.01 273.64,38.62
+LED_BL on BOTTOM (solid shape): outline of 89 points within 282.56,28.15 287.03,33.13
+RTC_CELL on TOP (solid shape): 158.2,72.05 158.2,71.72 158.3,71.61 159.88,71.61 159.93,71.56 159.93,71.19 159.85,71.12 159.64,71.12 158.84,70.32 154.44,70.32 154.08,70.67 154.08,72.2 154.16,72.27 157.97,72.27
+RTC_CELL on IN2 (solid shape): outline of 434 points within 153.81,78.42 156.32,86.85
+RTC_CELL on IN3 (solid shape): outline of 144 points within 21.37,7.45 25.23,12.08
+SMDDR_VREF_DQA on TOP (solid shape): 115.1,47.59 115.1,46.47 114.82,46.19 114.82,44.61 115.07,44.36 115.48,44.36 115.53,44.36 115.85,44.35 115.87,44.34 115.96,44.25 115.96,42.63 115.45,42.12 113.8,42.12 113.55,42.38 113.55,43.31 113.59,43.41 113.6,43.52 113.6,43.82 113.59,43.93 113.55,44.04 113.55,44.33 113.59,44.43 113.6,44.54 113.6,44.84 113.59,44.95 113.55,45.05 113.55,45.34 113.59,45.45 113.6,45.56 113.6,45.86 113.59,45.97 113.55,46.07 113.55,46.36 113.59,46.46 113.6,46.57 113.6,46.87 113.59,46.98 113.55,47.09 113.55,47.37 113.59,47.48 113.6,47.59 113.61,47.68 113.61,47.74 113.61,48.01 113.67,48.07 114.61,48.07
+USB_SIDE0_PWR on TOP (solid shape): 315.32,66.66 316.04,66.66 316.59,66.1 316.59,65.34 316.49,65.24 316.49,64.4 316.21,64.12 314.56,64.12 313.67,65.01 311.77,65.01 311.39,65.39 311.39,66.41 311.84,66.86 311.84,67.5 312.02,67.68 314.31,67.68
