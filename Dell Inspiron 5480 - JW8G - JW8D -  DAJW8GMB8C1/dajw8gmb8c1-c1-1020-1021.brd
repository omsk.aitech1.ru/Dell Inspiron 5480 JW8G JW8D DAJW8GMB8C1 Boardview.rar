# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_WDQS4: length 38.1
  TOP w0.102: v2(202.92,94.3) 202.65,94.3 202.5,94.45 202.5,94.58 202.72,94.8 203.16,94.8 203.44,94.52 204.81,94.52 205.56,95.27
  TOP w0.127: VRAM1.C7 219.51,108.37 219.31,108.57 218.57,108.57 218.22,108.92 218.22,110.37 216.11,112.48 211.49,112.48 210.91,111.91 v1(210.91,111.18) 210.18,111.18 209.87,110.87 209.38,110.87 209.19,110.68 209.19,109.96 208.53,109.29 207.69,109.29 207.32,108.92 207.32,101.51 207.02,101.21 206.51,101.21 206.36,101.05 206.36,100.64 206.48,100.51 207.05,100.51 207.32,100.24 207.32,99.65 207.05,99.37 206.48,99.37 206.36,99.24 206.36,96.07 205.56,95.27
  BOTTOM w0.127: U13.R25 202.92,94.32 v2(202.92,94.3)
VMA_WDQS5: length 34.4
  TOP w0.14: v2(217.01,105.94) 216.87,105.8 216.38,105.8 VRAM1.F3
  IN1 w0.102: v2(201.28,98.46) 201.28,98.69 201.4,98.82 201.56,98.82 201.68,98.69 201.68,98.13 201.86,97.95 203.05,97.95 203.51,98.41 204.15,98.41 206.71,100.98 206.71,103.19 208.04,104.51 208.04,107.12 208.28,107.37 208.56,107.37 208.78,107.15 208.94,107.15 209.25,107.46 209.25,107.6 209.05,107.8 209.05,108.11 209.46,108.52 209.77,108.52 209.97,108.32 210.11,108.32 210.4,108.61 210.4,108.75 210.2,108.95 210.2,109.26 210.61,109.67 210.92,109.67 211.12,109.47 211.26,109.47 211.55,109.76 211.55,109.9 211.35,110.1 211.35,110.42 211.97,111.03 213.24,111.03 213.46,110.81 213.46,110.45 213.58,110.32 213.95,110.32 214.07,110.44 214.07,110.81 214.29,111.03 214.71,111.03 215.55,110.2 215.55,108.52 216.67,107.4 216.67,106.54 216.54,106.41 216.54,105.73 216.65,105.62 216.75,105.62 217.01,105.89 v2(217.01,105.94)
  BOTTOM w0.127: U13.W23 201.28,98.4 v2(201.28,98.46)
VMA_WDQS6: length 33
  BOTTOM w0.102: VRAM3.C7 216.59,108.55 216.77,108.55 216.8,108.52
  BOTTOM w0.127: U13.AB26 203.67,100.87 205.41,100.87 207.07,102.53 207.07,104.38 209.41,106.72 209.41,112.03 210.49,113.12 212.37,113.12 212.64,112.84 212.64,111.94 212.79,111.8 213.01,111.8 213.28,112.06 213.28,112.84 213.55,113.12 214.15,113.12 214.42,112.84 214.42,112.38 214.55,112.25 214.93,112.25 215.06,112.38 215.06,112.84 215.33,113.12 216.93,113.12 217.23,112.82 217.23,112.1 217.41,111.92 217.41,110 217.99,109.41 217.99,108.82 217.69,108.52 216.8,108.52
VMA_WDQS7: length 31.2
  IN3 w0.127: v2(218.31,106.62) 217.86,107.06 217.86,107.35 217.43,107.78 216.16,107.78 215.81,108.14 215.36,108.14 215,107.78 214.41,107.78 214.05,108.14 213.25,108.14 212.73,107.63 212.73,106.73 212.34,106.33 211.69,106.33 211.41,106.62 210.63,106.62 210.35,106.34 210.35,105.78 210.22,105.65 209.49,105.65 209.18,105.34 209.18,104.89 209.7,104.37 209.7,104.15 209.52,103.97 208.87,103.97 208.62,103.72 208.62,101.94 207.53,100.85 207.53,100.25 207.14,99.86 206.99,99.86 206.83,100.02 206.45,100.02 206.18,99.75 206.18,95.58 206.03,95.44 205.85,95.44 205.6,95.69 205.6,96.4 205.26,96.73 204.25,96.73 204.02,96.51 204.02,96.25 203.74,95.97 v2(203.72,95.97)
  BOTTOM w0.127: U13.T26 203.39,95.54 203.72,95.87 v2(203.72,95.97)
  BOTTOM w0.14: VRAM3.F3 219.25,105.87 219.02,106.1 218.74,106.1 218.59,106.25 218.59,106.47 218.45,106.62 v2(218.31,106.62)
VMA_ZQ1: length 5.8
  TOP w0.229: 214.36,81.21 214.94,81.21 215.35,81.62 VRAM2.L8
  TOP w0.254: R85.2 210.43,82.16 v1(211.49,82.16) 211.7,82.16 212.28,81.57 214,81.57 214.36,81.21
VMA_ZQ2: length 8
  BOTTOM w0.102: v1(227.74,81.09) 227.69,81.15 R368.2
  BOTTOM w0.229: VRAM4.L8 220.71,82.01 224.31,82.01 224.54,81.77 226.02,81.77 226.32,81.47 226.32,81.38 R368.2
VMA_ZQ3: length 5
  TOP w0.229: R31.2 224.44,102.06 223.54,102.06 223.38,101.89 221.76,101.89 221.33,101.47 220.72,101.47
  TOP w0.254: 220.72,101.47 VRAM1.L8
VMA_ZQ4: length 5.9
  BOTTOM w0.229: R302.2 v1(211.84,101.09) 212.46,101.09 213.65,102.28 214.89,102.28 215.3,101.87 VRAM3.L8
VR_READY: length 20.1
  TOP w0.102: D1.1 127.87,115.36 v1(127.11,114.6) 127.1,114.59 R491.2 125.27,113.81 C197.1 125.27,112.95 125.97,112.25 125.97,111.43 125.46,110.92 R15.2 125.46,110.45 125.88,110.03 125.88,108.42 125.46,108 R18.2 125.46,102.88 v2(125.28,102.7)
  BOTTOM w0.076: 123.63,102.53 123.63,102.12 123.81,101.94 123.81,100.72 124.09,100.44 U14.C59
  BOTTOM w0.102: 123.63,102.53 123.88,102.78 125.2,102.78 v2(125.28,102.7)
VR_SVID_ALERT#: length 51.8
  TOP w0.102: v2(116.06,93.71) 114.99,93.71 114.28,94.42 112.56,94.42 v1(112.12,94.86) 111.18,95.79 111.18,99.04 110.57,99.65 110.57,102.73 106.59,106.72 105.28,106.72 v2(105.27,106.73)
  IN1 w0.089: v2(105.27,106.73) 105.49,106.96 105.5,106.96 105.85,107.31 105.85,107.89 105.44,108.29 105.44,118.77 108.63,121.96 111.36,121.96 111.79,122.39 v2(115.17,122.39)
  IN2 w0.114: v2(116.06,93.71) 116.06,93.97 115.3,94.73 115.3,95.59 115.74,96.04 v2(116.14,96.04)
  BOTTOM w0.076: 115.9,95.53 116.52,95.53 116.99,96 R312.2 ; R321.2 v2(116.06,93.71)
  BOTTOM w0.102: v2(115.17,122.39) 115.52,122.04 PR138.2 ; v2(116.14,96.04) 116.14,96.05 116.09,96 R313.2 115.43,95.66 115.57,95.53 115.9,95.53
VR_SVID_CLK: length 49.5
  TOP w0.102: v2(119.49,93.74) 118.96,93.2 116.48,93.2 116.38,93.31 115.07,93.31 114.31,94.07 113.8,94.07 113.55,93.81 112,93.81 110.57,95.24 110.57,98.79 109.96,99.4 109.96,101.99 v1(109.36,102.6) 109.3,102.65 109.3,103.14 106.36,106.08 v2(106.03,106.08)
  IN1 w0.089: v2(106.03,106.08) 106.51,106.56 106.51,108.34 106.05,108.8 106.05,118.53 109.14,121.62 112.27,121.62 112.58,121.93 114.59,121.93 v2(114.64,121.98)
  BOTTOM w0.076: U14.N63 121.33,94.56 121.28,94.61 120.37,94.61 v2(119.49,93.74)
  BOTTOM w0.102: v2(114.64,121.98) 115.04,121.58 PR142.2
VR_SVID_DATA: length 54
  TOP w0.102: v2(117.74,94.3) 117.64,94.19 116.01,94.19 115.3,94.91 114.41,94.91 114.28,95.03 112.96,95.03 111.79,96.2 111.79,99.3 111.18,99.91 111.18,100.71 v1(111.18,100.71) 111.18,100.71 111.18,103.01 106.86,107.33 105.48,107.33 v2(105.25,107.56)
  IN1 w0.089: v2(105.25,107.56) 105.22,107.56 104.83,107.94 104.83,119.09 108.08,122.33 108.16,122.33 108.17,122.34 108.66,122.34 108.67,122.33 111.08,122.33 111.92,123.18 115.35,123.18 v2(115.86,122.67)
  BOTTOM w0.076: U14.L63 121.39,95.18 119.53,95.18 119.33,94.98 118.85,94.98 118.73,94.86 R316.2 118.47,94.48 118.47,94.08 R320.2 118.1,93.93 v2(117.74,94.3)
  BOTTOM w0.102: v2(115.86,122.67) 115.88,122.64 116.9,122.64 117.33,122.21 PR137.2
VREF: length 5
  TOP w0.102: C338.2 310.7,30.09 310.35,29.73 v1(310.27,29.73)
  TOP w0.305: U10.25 310.4,31.78 310.96,31.23 C332.1 311.91,31.08 311.91,30.23 311.77,30.09 C338.2
VREFC_VMA1: length 31.5
  TOP w0.102: v2(224.72,83.81) v1(223.93,83.81)
  TOP w0.229: v2(212.48,82.05) 212.6,81.93 214.27,81.93 214.35,82.01 215.11,82.01 VRAM2.M8
  IN3 w0.254: v2(224.72,83.81) 224.24,83.81 223.53,83.09 223.53,82.38 220.96,79.82 217.74,79.82 217.53,79.62 215.07,79.62 214,80.68 213.19,80.68 212.48,81.39 v2(212.48,82.05)
  BOTTOM w0.229: VRAM4.M8 220.72,82.82 220.72,83.38 220.96,83.62 221.28,83.62 221.29,83.64 222.93,83.64 223.27,83.31 C440.1
  BOTTOM w0.254: C440.1 R366.2 226.86,83.31 227.04,83.48 227.04,84.39 226.86,84.57 R360.1 226.43,84.09 226.31,83.97 224.89,83.97 v2(224.72,83.81)
VREFC_VMA3: length 20.1
  TOP w0.229: C37.1 224.65,98.91 224.6,98.91 224.26,99.25 223.78,99.25 222.37,100.67 v2(220.72,100.67) VRAM1.M8
  TOP w0.254: R47.1 225.25,95.98 225.25,97.41 225.13,97.53 R41.2 224.55,97.75 223.75,97.75 223.42,98.08 223.42,98.55 223.65,98.78 C37.1
  IN1 w0.254: v2(220.72,100.67) 220.48,100.43 220.48,99.58 219.49,98.59 217.07,98.59 215.1,100.56 v2(215.1,100.7)
  BOTTOM w0.229: v2(215.1,100.7) 215.47,101.07 VRAM3.M8
VREFD_VMA1: length 24.5
  TOP w0.102: R89.1 225.76,81.27 226.22,80.81 227.36,80.81 v1(227.57,81.01)
  TOP w0.229: C170.1 225.38,79.23 225.08,79.54 221.44,79.54 VRAM2.H1
  TOP w0.254: v2(224.67,81.27) R89.1 R93.2 C170.1
  IN3 w0.254: v2(213.77,79.82) 214.08,79.82 215.65,78.24 216.24,78.24 216.8,77.68 219.57,77.68 221.9,80.02 223.43,80.02 v2(224.67,81.27)
  BOTTOM w0.254: v2(213.77,79.82) 213.9,79.82 214.51,79.21 VRAM4.H1
VREFD_VMA3: length 21.5
  TOP w0.254: VRAM1.H1 213.96,103.52 213.29,103.52 213.01,103.8 v2(213.01,104.02)
  IN2 w0.254: v2(221.8,103.49) 221.57,103.72 220.53,103.72 220.1,103.29 219.34,103.29 218.7,103.92 214.69,103.92 214.18,103.41 213.29,103.41 213.01,103.69 v2(213.01,104.02)
  BOTTOM w0.254: C420.1 R296.2 225.04,104.26 225.28,104.02 225.28,102.74 R301.1 223.57,102.23 223.3,102.5 223.3,103.49 223.1,103.69 222,103.69 v2(221.8,103.49) 221.39,103.9 221.39,104 VRAM3.H1
VREFF_CA_A: length 4.3
  TOP w0.102: v1(161.35,35.01) 161.35,36.49 R202.1
  TOP w0.508: R198.1 162.92,36.95 C298.2 R202.1
VREFOUT_AL: length 4.1
  TOP w0.254: v1(311.08,28.26) 310.77,28.57 R267.2 310.09,28.6 310.09,28.81 308.56,30.35 U10.23
WLAN_CLKREQ#: length 20.1
  TOP w0.102: Q46.5 90.15,33.16 90.37,33.38 R501.2 89.75,34.12 89.19,34.68 84.18,34.68 v1(83.8,34.3) 83.65,34.15 v2(82.63,34.15) 82.63,34.43 82.14,34.92 80.61,34.92 80.13,34.44 R225.1
  BOTTOM w0.102: CN14.53 80.24,38.45 80.55,38.14 80.55,37.15 82.63,35.06 v2(82.63,34.15)
WLAN_EC_PWR_EN#: length 193.1
  TOP w0.102: v2(230.77,19.65) 230.61,19.8 230.61,23.46 231.12,23.96 233.36,23.96 233.59,24.19 233.59,27.19 233.77,27.37 233.77,28.48 233.21,29.04 233.21,30 235.72,32.51 235.72,37.93 v1(236.22,38.43) v2(236.91,39.13) ; v2(90.33,25.31) 91.52,26.5 Q27.2
  IN1 w0.089: v2(90.33,25.31) 91.78,26.76 99.07,26.76 99.27,26.55 110.57,26.55 117.79,33.77 137.85,33.77 140.67,30.95 143.6,30.95 144.77,29.78 145.47,29.78 147.68,27.57 154.06,27.57 154.72,28.23 154.72,30.03 157.72,33.03 179.94,33.03 182.89,30.08 182.89,28.33 182.34,27.79 182.34,23.7 185.48,20.56 185.48,19.51 187.23,17.75 198.9,17.75 201.12,19.97 201.61,19.97 201.86,19.73 201.86,19.35 202.09,19.11 202.11,19.11 203.76,17.47 228.59,17.47 v2(230.77,19.65)
  BOTTOM w0.102: U23.78 236.87,39.09 v2(236.91,39.13)
WLAN_EC_WAKE#: length 196.5
  TOP w0.102: v2(96.17,24.93) 95.18,23.94 95.18,21.8 93.91,20.53 90.13,20.53 89.58,21.08 86.61,21.08 85.09,22.6 85.09,25.86 84.49,26.45 83.4,26.45 82.46,27.39 81.67,27.39 80.87,28.19 79.8,28.19 78.8,27.19 78.62,27.19 77.45,26.02 75.42,26.02 74.28,27.16 74.28,28.46 72.31,30.43 72.31,32.05 71.23,33.13 v1(71.23,33.77) 71.1,33.9 70.47,33.9 69.83,34.53 SJ2.2
  IN3 w0.114: v2(228.81,21.02) 227.74,19.95 210.57,19.95 210.32,20.2 208.55,20.2 207.37,21.37 204.17,21.37 202.95,22.59 202.39,22.59 201.04,23.94 191.83,23.94 189.37,26.4 187.61,26.4 186.64,27.37 186.64,28.31 185.95,29.01 184.04,29.01 179.25,33.79 157.49,33.79 154.87,31.18 147.28,31.18 146.49,31.97 145.7,32.75 128.31,32.75 120.05,32.75 119.5,32.21 115.01,32.21 109.43,26.63 105.39,26.63 104.15,25.39 96.63,25.39 v2(96.17,24.93)
  BOTTOM w0.102: v2(228.81,21.02) 228.81,21.14 230.34,22.67 230.34,24.83 231.76,26.25 231.76,26.91 231.86,27.01 231.86,28.66 231.09,29.43 U23.104
WLAN_ON/OFF#: length 145.2
  TOP w0.102: v2(82.56,26.63) 82.03,27.16 81.47,27.16 80.82,27.81 79.78,27.81 78.9,26.94 78.72,26.94 77.55,25.77 75.29,25.77 74.02,27.04 74.02,28.31 71.57,30.76 v1(71.57,31.85) 71.57,32.1 70.26,33.41 Q23.1 68.19,34.65 R218.1
  IN3 w0.114: v2(82.56,26.63) 82.56,26.91 85.61,29.96 90.11,29.96 90.94,30.79 101.51,30.79 104.73,34.01 104.8,34.01 108.16,37.37 108.16,38.7 108.8,39.33 108.8,43.81 111.01,46.02 111.01,46.21 111.01,47.25 115.97,52.21 115.97,62.84 116.73,63.61 116.73,64.14 116.73,66.02 116.73,66.21 116.73,69.93 120.8,74 120.8,74.94 123.5,77.64 123.5,78.68 126.35,81.52 126.35,84.46 126.96,85.08 129.27,85.08 130.79,86.6 130.89,86.6 132.59,88.3 146.77,88.3 147.33,87.75 148.62,87.75 148.91,87.46 151.78,87.46 152.21,87.03 154.24,87.03 154.5,86.77 154.5,85.79 154.9,85.39 155.63,85.39 155.89,85.13 155.89,81.9 156.28,81.51 157.19,81.51 157.84,82.16 v2(157.84,82.18)
  BOTTOM w0.102: U14.AT5 157.39,81.71 157.84,82.16 v2(157.84,82.18)
WLAN_ON/OFF#_R: length 19.8
  TOP w0.102: v2(63.2,32.7) 64.24,33.74 v1(65.44,33.74) 65.44,33.12 65.4,33.08 R236.1 Q23.3 67.45,34.62 R218.2
  BOTTOM w0.102: CN14.56 71.08,39.2 69.39,37.51 69.39,35.99 67.04,33.64 64.14,33.64 v2(63.2,32.7)
WLAN_WAKE#: length 3.4
  TOP w0.102: v1(70.01,36.87) 70.01,35.86 SJ2.1 68.35,35.68 Q21.3
WLAN_WAKE#_R: length 15.9
  TOP w0.102: R197.1 66.45,38.11 Q21.1 67.24,38.67 68.31,39.74 v1(72.25,39.74) 72.88,39.74 74.86,37.76 v2(75.57,37.76)
  BOTTOM w0.102: CN14.55 78.63,38.95 78.35,38.67 77.02,38.67 76.11,37.76 v2(75.57,37.76)
WOOFER_EN: length 20.8
  TOP w0.102: Q31.2 285.67,24.24 285.25,24.66 285.25,26.24 v1(284.79,26.69) 284.2,27.29 283.61,27.29 283.37,27.53 283.37,30.44 282.84,30.97 C393.2 ; C393.2 R246.2 ; C393.2 283.08,31.65 283.53,32.1 Q24.3 285.09,32.1 286.09,31.1 287.05,31.1 288.2,32.24 289.85,32.24 291.07,31.02 Q25.2
WRST#: length 11.4
  BOTTOM w0.102: v1(211.87,37.91) 212.38,37.4 212.7,37.4 212.97,37.12 R468.1 213.32,36.69 213.72,36.28 215.04,36.28 215.13,36.37 C502.1 215.13,37.76 215.58,38.21 216.04,38.21 216.24,38.01 216.24,37.6 216.95,36.89 218.55,36.89 218.74,37.09 U23.14
XDP_TCK0: length 45.3
  TOP w0.102: R10.1 120.59,113.77 120.86,113.49 120.86,112.53 120.86,112.53 120.86,111.64 120.53,111.31 120.53,110.78 121.07,110.24 121.07,104.31 120.33,103.56 120.33,101.64 121.46,100.5 121.46,99.97 121.92,99.51 v2(123.13,99.51) 123.13,98.65 121.78,97.29 121.78,95.16 122.16,94.78 123.79,94.78 124.48,94.1 124.48,91.75 124.87,91.35 124.87,90.56 v1(124.11,89.8) 123.86,89.55 123.86,87.97 123.3,87.41 118.25,87.41 113.5,87.41 v2(113.38,87.3)
  BOTTOM w0.076: v2(123.13,99.51) 123.47,99.18 U14.E60
  BOTTOM w0.102: R347.1 113.83,86.85 v2(113.38,87.3)
XDP_TCK1: length 6.1
  BOTTOM w0.102: U14.AE62 122.16,87.75 121.91,87.49 120.84,87.49 119.19,85.84 R351.2 117.56,85.35 v1(117.56,84.92)
XDP_TDI: length 16.2
  TOP w0.102: v1(109.33,87.62) 110.22,88.51 111.11,88.51 R63.2 111.9,88.28 113.24,88.28 113.5,88.02 114.3,88.02 114.84,88.56 119.58,88.56 120.17,87.97 121.06,87.97 121.73,88.63 122.89,88.63 123.15,88.38 v2(123.15,88.17)
  BOTTOM w0.076: v2(123.15,88.17) 123.15,88.2 122.81,88.53 U14.AD61
XDP_TDO_CPU: length 11.1
  TOP w0.102: v2(120.15,97.62) 119.92,97.4 117.84,97.4 117.33,97.9 116.34,97.9 115.82,98.42 115.82,99.41 v1(114.92,100.32) 114.51,100.72 113.85,100.72 R33.1
  BOTTOM w0.076: v2(120.15,97.62) 120.23,97.62 120.62,98.02 120.95,98.02 120.95,98.01 121.64,98.01 121.93,98.3 U14.F62
XDP_TMS: length 4.8
  BOTTOM w0.076: R340.2 118.77,87.87 v1(119.29,87.36) 119.94,88.02 121.23,88.02 121.32,88.11 121.7,88.11 122.16,88.56 U14.AD62
XDP_TRST_CPU_N: length 32.6
  TOP w0.102: v2(120.2,85.81) 120.2,86.17 120.51,86.47 122.87,86.47 124.06,87.67 124.06,88.63 125.08,89.65 125.08,91.44 124.68,91.83 124.68,94.18 123.78,95.08 122.26,95.08 122.06,95.29 122.06,96.51 v1(123.02,97.47) 123.35,97.8 123.35,99.08 v2(123.78,99.51)
  BOTTOM w0.076: v2(123.78,99.51) 124.12,99.18 U14.E59
  BOTTOM w0.102: U14.AU62 121.79,81.45 120.63,81.45 120.2,81.88 v2(120.2,85.81) 119.77,85.81 118.32,84.36 116.83,84.36 115.82,85.38 R353.1
XTAL24_IN: length 11.5
  BOTTOM w0.076: U14.A25 145.58,101.89 145.58,104.25 145.11,104.71 142.49,104.71 R292.1 C422.1 143.31,105.48 142.94,105.85 Y1.3 143.23,106.58 144.31,107.66 v1(144.31,108.01)
XTAL24_OUT: length 14.6
  BOTTOM w0.076: 140.7,108.32 Y1.1 140.66,108.28 139.76,107.38 139.76,105.41 C423.1 R292.2 141.92,104.51 142.38,104.51 142.43,104.56 145.05,104.56 145.42,104.18 145.42,102.16 145.14,101.88 145.14,101.62 145.43,101.33 U14.B25
  BOTTOM w0.102: 140.7,108.32 140.47,108.55 v1(140.47,109.89)
XTAL_SSIN: length 9.2
  BOTTOM w0.102: U13.A10 190.08,81.73 188.53,80.17 188.53,78.85 188.53,78.85 188.53,77.93 R381.1 187.94,77.33 188.37,76.9 188.37,75.5 v1(188.1,75.22)
N20714548: length 2.4
  TOP w0.102: R274.1 207.37,25.9 v2(207.37,26.83)
  BOTTOM w0.102: v2(207.37,26.83) 207.32,26.89 CN16.26
N23727870: length 3.9
  TOP w0.102: v1(301.38,26.83) 301.38,27.11 300.57,27.93 C354.2 R258.1 300.23,28.95 C345.2
N30510538: length 2.6
  TOP w0.102: v2(177.11,38.05) 177.15,38.01 R203.1
  BOTTOM w0.102: v2(177.11,38.05) JDIM1.198
N77718867: length 12
  TOP w0.102: R128.1 R132.1 114.28,69.96 116.31,67.93 116.31,67.42 116.94,66.8 v1(117.64,66.8) R138.2 118.54,67.11 118.54,68.62 118.71,68.79 Q13.2
N93290362: length 5.7
  BOTTOM w0.102: v2(183.98,77.23) 183.37,76.62 Q35.1 181.9,76.62 180.73,75.45 Q38.3
N106078187: length 2.9
  BOTTOM w0.254: R471.2 194.23,33.01 v1(194.22,33.01)
  BOTTOM w0.508: R471.2 195.67,33.01 195.92,33.26 U24.3
N106078293: length 6.5
  BOTTOM w0.102: R473.2 205.97,31.99 U24.7 203.59,31.99 203.28,31.69 203.28,29.58 203.46,29.4 v1(204.1,29.4)
N106078316: length 3.2
  BOTTOM w0.102: U21.3 203.59,40.25 204.61,39.23 R462.2
N106078324: length 6.4
  BOTTOM w0.102: U21.7 191.85,41.52 191.23,42.14 R451.2 190.26,42.14 189.61,42.8 v1(189.61,43.42)
N122930874: length 13.5
  TOP w0.102: v2(162.21,83.5) 162.21,78.97 162.64,78.53 162.64,78.1 163.66,77.08 163.66,76.74 TP53.1
  BOTTOM w0.076: U14.AP4 158.5,82.87 158.96,82.87 159.01,82.82 159.68,82.82 159.85,82.99 160.37,82.99 160.46,83.08 161.63,83.08
  BOTTOM w0.102: 161.63,83.08 161.79,83.08 v2(162.21,83.5)
N123894080: length 9.1
  TOP w0.102: R21.1 147.07,107.27 v1(147.07,106.18) 147.07,105.5 145.56,103.98 145.56,102 v2(144.84,101.28)
  BOTTOM w0.076: U14.C26 144.87,100.35 144.56,100.65 144.56,100.93 144.84,101.21 v2(144.84,101.28)
N124584583: length 5.5
  TOP w0.102: v2(283.7,26.02) 282.93,26.79 R479.2 R239.1
  BOTTOM w0.102: v2(283.7,26.02) 283.93,26.25 C521.2
  BOTTOM w0.254: C521.2 283.93,27.39 284.08,27.55 Q28.2
N124584682: length 24.8
  TOP w0.102: Q26.2 278.65,29.73 279.38,30.47 281.41,30.47 v2(281.8,30.09) ; R238.2 R235.2 265.51,33.21 v1(265.37,33.07) 266.35,32.09 269.38,32.09 v2(269.98,31.48)
  IN3 w0.114: v2(269.98,31.48) 271.38,30.09 v2(281.8,30.09)
N126037216: length 18.4
  TOP w0.102: v1(156.45,91.38) 156.19,91.11 v2(155.73,91.11)
  TOP w0.508: v2(165.16,91.28) 165.17,91.3 165.49,91.3 165.62,91.17 C116.2 R56.2
  IN2 w0.203: 159.95,91.38 159.59,91.74 158.02,91.74 157.88,91.6 156.22,91.6 v2(155.73,91.11) 156.2,90.64 156.58,90.64 156.6,90.63 156.83,90.63 156.83,90.64 156.96,90.64 156.96,90.63 157.36,90.63 157.37,90.64 157.48,90.64 157.48,90.64 157.88,90.64 157.92,90.61 159.6,90.61 159.85,90.87
  IN2 w0.508: 160.13,91.48 161.78,91.48 162.63,92.33 162.63,92.4 163,92.76 163.06,92.76 163.08,92.77 163.58,92.77 165.07,91.28 v2(165.16,91.28)
  BOTTOM w0.254: U14.Y8 155.56,90.94 v2(155.73,91.11)
N128064339: length 28.9
  BOTTOM w0.102: U23.21 218.72,39.89 218.35,39.52 217.98,39.52 217.46,39 209.67,39 207.35,41.32 207.35,42.28 205.77,43.85 201.48,43.85 201.08,43.85 v1(200.21,44.72) 198.71,46.21 198.71,48.05 198.06,48.7 198.05,48.7 197.59,49.16 D12.2
N128064405: length 29.9
  BOTTOM w0.102: D11.1 198.46,51.42 198.92,50.96 198.92,49.29 199.73,48.47 199.73,46.61 201.5,44.84 206.18,44.84 v1(207.53,43.5) 208.31,42.71 208.31,41.72 210.02,40.02 218.19,40.02 218.86,40.69 U23.23
N128064409: length 6.8
  BOTTOM w0.102: U23.4 218.85,33.09 218.8,33.13 217.61,33.13 217.48,33.01 v1(217.13,33.01) 216.8,33.01 215.98,32.19 215.32,32.19 214.94,31.81 214.05,31.81 D21.1
N128064579: length 5.5
  BOTTOM w0.102: U23.12 218.14,36.29 217.84,35.98 217.84,35.47 217.69,35.32 216.74,35.32 C504.2 215.36,35.66 v1(215.27,35.75)
N128064904: length 5.2
  BOTTOM w0.203: U23.75 236.81,40.29 236.82,40.29
  BOTTOM w0.508: 236.82,40.29 236.94,40.29 236.95,40.28 v1(237.57,40.28) 238.32,40.28 238.49,40.11 C491.1 240.5,40.11 L25.1
N128065097: length 9.4
  BOTTOM w0.102: v1(243.95,39.18) 243.48,39.18 243.05,39.6 R459.1 242.68,40.12 242.17,39.61 238.29,39.61 238.16,39.74 236.5,39.74 236.36,39.89 U23.76
N128065099: length 7.9
  BOTTOM w0.102: U23.77 236.38,39.49 236.43,39.53 238.01,39.53 238.13,39.41 239.86,39.41 240.42,38.85 R465.1 240.77,39.21 240.84,39.28 242.35,39.28 v1(242.65,38.98)
N128065117: length 8.6
  BOTTOM w0.102: v1(242.83,37.65) 242.5,37.98 240.88,37.98 240.04,37.15 239.58,37.15 239.4,37.32 D20.1 238.87,37.86 238.57,38.16 236.81,38.16 236.54,37.89 U23.81
N128622958: length 4.2
  TOP w0.102: v1(314.28,78.98) 314.68,79.38 R95.1 314.31,80 314.1,80.2 314.1,80.96 313.8,81.26 U2.12
N128622966: length 3.6
  TOP w0.102: v2(314.03,82.71) 313.7,82.71 313.45,82.46 U2.15
  BOTTOM w0.102: v1(314.74,82.84) 314.16,82.84 v2(314.03,82.71) 313.35,82.71 R363.1
N128623205: length 6.3
  TOP w0.102: U2.18 313.17,83.66 313.62,84.11 313.62,84.36 314.18,84.92 314.18,85.89 314.38,86.09 R72.2 314.68,86.38 314.92,86.62 314.92,86.89 315.17,87.13 315.86,87.13 v1(316.24,87.51)
N128623427: length 5.5
  TOP w0.102: 306.23,82.97 306.07,82.81 306.07,82.1 305.7,81.72 v1(305.7,81.47) ; 306.23,82.97 306.08,83.12 306.08,83.28 R82.2 R75.2 ; 306.23,82.97 306.66,82.97 307.17,82.46 U2.36
N128983961: length 2.4
  TOP w0.102: v1(216.24,31.71) 217.03,32.51 EC6.1 R223.1
N129561392: length 4.4
  BOTTOM w0.305: U18.8 24.94,54.02 24.57,53.66 v1(24.57,53.3) 25.02,52.85 R419.2 25.54,53.2 25.44,53.3 U18.7
N129561428: length 2.4
  BOTTOM w0.102: U18.16 26.44,58.27 26.44,58.27 26.44,58.49 25.31,59.63 R430.2
N129841983: length 9.3
  TOP w0.102: R146.2 R148.2 114.76,53.97 114.49,54.24 114.49,54.76 114.26,54.99 113.89,54.99 113.79,54.89 U5.5 113.79,53.34 113.52,53.07 112.76,53.07 112.07,52.39 v1(111.44,52.39) 111.12,52.06 C212.1
N129843308: length 5.2
  TOP w0.102: R141.2 R142.2 ; R142.2 113.77,57.65 113.14,57.02 U5.2 ; R142.2 R143.2 v1(115.85,58.02)
N129844102: length 2.8
  TOP w0.102: v1(108.75,49.9) R154.2 109.83,49.43 110.22,49.04 Q18.3
N129885414: length 3.2
  TOP w0.102: U9.28 54.44,38.29 54.39,38.34 R188.2 53.46,37.87 53.7,37.63 v2(53.7,37.45)
N129957604: length 2.2
  TOP w0.102: R207.2 v1(163.04,35.08)
  TOP w0.508: R207.2 162.92,36.17 C298.1
N129964663: length 2.5
  TOP w0.102: C215.1 114.54,48.75 v1(114.92,49.14)
  TOP w0.457: R153.2 113.9,49.67 113.78,49.55 C215.1
N130076878: length 7.6
  TOP w0.254: Q29.3 87.12,29.89 C342.1 87.4,29.93 R244.1 88.51,29.06 88.74,28.83 88.74,28.04 v1(88.86,27.93) 89.62,27.16 Q27.3
N130191757: length 4.8
  BOTTOM w0.102: R414.1 304.03,70.44 304.13,70.55 Q40.6 ; R414.1 304.5,69.84 304.78,70.12 Q40.5 ; R414.1 304.03,69.32 v1(304.45,68.9)
N130315674: length 5.6
  TOP w0.102: D5.1 217.91,36.92 217.03,37.81 v2(216.67,37.81)
  BOTTOM w0.102: U23.15 218.79,37.49 218.42,37.12 217.36,37.12 v2(216.67,37.81)
N130323284: length 6.1
  TOP w0.102: R155.2 107.3,47.73 Q19.5 107.3,45.91 107.17,45.78 106.74,45.78 106.65,45.87 Q19.6 106.65,47.47 106.13,47.99 v1(106.03,47.99)
N130397772: length 2.9
  BOTTOM w0.102: R429.2 24.79,59.24 25.38,59.24 25.94,58.69 U18.15
N130398206: length 4.8
  BOTTOM w0.305: U18.4 27.76,55.47 28.51,54.72 v1(28.51,54.09) 28.51,53.31 R421.2 R420.2
N130449913: length 8.7
  BOTTOM w0.076: U14.B8 155.52,101.1 155.9,101.47 155.9,101.8 157.21,103.11 157.74,103.11 158.15,103.52
  BOTTOM w0.102: 158.15,103.52 158.48,103.85 160.66,103.85 161.91,105.09 R293.2
N130831290: length 6.5
  TOP w0.102: C355.1 307.91,28.61 307.91,28.03 307.81,27.93 307.54,27.93 307.44,27.82 307.44,26.87 306.15,25.58 v1(306.15,25.52)
  TOP w0.305: C355.1 307.96,29.04 307.56,29.44 U10.21
N130831312: length 2.6
  TOP w0.305: U10.1 302.54,37.28 302.22,37.6 302.22,37.96 v1(301.81,38.37) 301.58,38.59 C273.2
N130831320: length 8.1
  TOP w0.102: U10.7 302.08,34.28 301.83,34.02 301.2,34.02 300.68,33.5 299.53,33.5 299.44,33.41 298.93,33.41 298.55,33.03 297.66,33.03 R231.2 296.91,32.51 296.29,32.51 v1(295.66,31.89)
N130831363: length 16
  TOP w0.305: U10.3 302.2,36.28 302,36.48 301.99,36.48 301.61,36.87 300.63,36.87 C304.2 300.82,35.84 v2(300.82,35.77)
  IN3 w0.305: v2(300.82,35.77) 300.49,36.1 300.49,37.48 300.01,37.96 297.92,37.96 297.49,38.39 297.49,39.15 v2(297.16,39.48)
  BOTTOM w0.102: 297.44,40.14 297.44,39.76 v2(297.16,39.48)
  BOTTOM w0.305: v2(297.16,39.48) 296.99,39.66 296.49,40.17 C494.1 296.3,40.27 295.74,40.83 294.2,40.83 R461.2 ; 297.44,40.14 v1(297.44,40.42)
N130831369: length 2.8
  TOP w0.305: R266.1 309.1,28.72 308.31,29.5 v1(308.31,29.7) 308.06,29.96 U10.22
N130831515: length 2.6
  TOP w0.305: U10.34 310.8,36.28 v1(311.12,36.6) 311.59,37.07 C289.2
N131133774: length 3.8
  TOP w0.102: R466.2 R172.1 258.53,43.2 Q20.6 257.14,43.91 v1(257.13,43.9)
N131135141: length 6.9
  TOP w0.102: R169.1 260.08,43.42 259.62,43.88 259.62,44.87 259.97,45.21 Q20.3 262.1,45.21 262.21,45.33 v1(262.9,45.33) 262.9,44.51 262.74,44.35 R484.2
N131184695: length 22.3
  IN1 w0.089: v2(156.4,93.01) 156.4,93.03 156.87,93.51 157.89,93.51 158.29,93.12 159.1,93.12 160.05,94.07 162.59,94.07 163.28,93.38 163.92,93.38 164.53,92.77 165.97,92.77 166.91,91.83 v2(167.5,91.83)
  BOTTOM w0.102: v2(167.5,91.83) 167.65,91.68 167.95,91.68 168.26,91.38 169.02,91.38 169.57,91.93 169.57,92.28 170.22,92.92 170.95,92.92 171.05,93.03 171.53,93.03 171.8,92.76 171.8,91.18 171.56,90.94 170.69,90.94 170.54,90.79 R329.2 ; U14.U7 156.21,92.84 156.4,93.03 v2(156.4,93.01)
N131237173: length 3.3
  TOP w0.102: U6.31 290.8,45.09 v2(291.07,44.82)
  BOTTOM w0.102: v2(291.07,44.82) 291.55,44.33 v1(291.8,44.33) 291.98,44.33 292.33,44.68 R441.1
N131663614: length 5.2
  TOP w0.102: R4.1 v1(157.23,117.85) 156.89,117.51 156.89,115.95 156.5,115.56 Q4.3
N131663616: length 6.9
  TOP w0.102: R7.1 R6.2 PR14.2 v1(168.59,115.31) 168.22,115.31 167.72,115.81 167.72,116.17 167.17,116.72 166.76,116.72 166.61,116.88 Q3.5
N131663662: length 17.8
  TOP w0.102: Q4.2 154.67,114.26 155,114.59 157.55,114.59 R11.1 158.83,113.99 159.39,113.42 Q5.2 159.85,114.08 160.03,114.26 v1(162.62,114.26) 164.5,114.26 164.83,113.93 166.3,113.93 166.61,114.24 Q3.2 166.61,116.29 166.71,116.39 167.14,116.39 167.27,116.27 167.27,115.54 Q3.3
N131663684: length 4
  TOP w0.102: v1(158.45,115.4) Q5.3 160.51,116.01 161.27,116.78 R5.1
N131663741: length 27
  TOP w0.102: v2(170.39,117.79) 170.39,118.2 170.2,118.39 PQ1.4 ; R4.2 159.33,117.07 159.51,117.25 159.51,117.67 159.69,117.85 PC8.1 R5.2 162.15,117.85 v1(162.19,117.89) 162.39,118.1 162.39,123.48 163.84,124.93 170.67,124.93 v2(171.03,124.57)
  IN3 w0.114: v2(170.39,117.79) 170.39,124.01 170.95,124.57 v2(171.03,124.57)
N131663808: length 3.2
  TOP w0.102: Q3.6 165.96,116.73 165.28,116.06 PR12.1 v1(163.91,116.06)
N131687489:
  vias: v1(284.23,40.45)
N131687511: length 4.4
  TOP w0.102: v1(286.22,40.68) 285.53,40.68 284.58,39.73 PC42.1 284.07,39.49 PU2.6
N131800584: length 12.3
  TOP w0.102: R70.2 179.19,86.79 179.46,87.06 180.53,87.06 181.69,88.23 181.69,88.73 v2(182.13,89.17) 182.41,89.44 183.02,89.44 v1(183.45,89.01)
  BOTTOM w0.102: v2(182.13,89.17) 182.35,89.39 183.73,89.39 183.93,89.19 183.93,88.78 184.13,88.58 184.36,88.58 184.64,88.3 184.64,87.84 184.82,87.67 186.37,87.67 186.73,87.3 U13.F6
N131966494: length 2.7
  TOP w0.102: R239.2 281.3,28.95 280.63,28.28 Q26.3
N132058185: length 10.1
  TOP w0.114: v1(119.68,31.03) 119.68,31.58 119.89,31.79 PR78.1
  TOP w0.254: PQ13.2 126.12,33.55 124.67,33.55 124.01,32.89 PQ12.3 122.79,32.89 122.13,33.55 121.06,33.55 PC50.2 120.68,32.8 120.56,32.68 120.12,32.68 119.89,32.45 PR78.1
N132058193: length 6.9
  TOP w0.102: v1(139.9,29.57) 141.44,31.11 PQ14.2 141.84,30.28 142.01,30.12 142.39,30.12 142.63,29.89 142.63,29.5 PR91.1
  TOP w0.114: PQ15.3 143.01,31.11 PQ14.2
N132058210: length 2.5
  BOTTOM w0.254: PC181.1 137.31,24.94 v1(137.82,25.45)
  BOTTOM w0.508: PC181.1 PR199.1
N132058229: length 5.4
  TOP w0.114: PR113.1 131.45,22.51 130.08,22.51 v1(129.9,22.34)
  TOP w0.279: PC74.2 131.71,24.2 PU4.16
  TOP w0.508: PR113.1 131.96,23.01 131.96,23.95 PC74.2
N132058301: length 13
  TOP w0.254: PU4.18 132.71,25.68 132.82,25.56 133.15,25.56 v2(133.36,25.78) ; PR90.2 140.62,29.49 v2(140.6,29.51)
  BOTTOM w0.254: v2(133.36,25.78) 133.34,25.78 133.11,26.01 v1(133.11,27.14) 133.11,28.13 134.18,29.21 136.61,29.21 137.19,28.62 139.71,28.62 v2(140.6,29.51)
N132058366: length 1.3
  BOTTOM w0.254: PC179.1 PR198.1
N132058395: length 2.5
  TOP w0.508: PR98.2 124.01,26.8 123.61,26.4 v1(123.61,26.26) 123.99,25.88 PC69.2
N132058414: length 17
  TOP w0.254: PR75.2 136.21,32.92 136.4,32.73 138.32,32.73 138.65,32.41 140.48,32.41 140.63,32.26 140.63,31.24 139.25,29.87 139.25,27.9 139.83,27.33 v1(142.16,27.33) 144.51,27.33 v2(144.66,27.17)
  BOTTOM w0.127: PR196.2 145.2,26.82
  BOTTOM w0.254: 145.2,26.82 145.02,26.82 v2(144.66,27.17)
N132058422: length 17.8
  TOP w0.254: v2(116.29,31.02) 116.29,31.76 v1(116.84,32.31) 117.72,32.31 119.59,34.17 129.73,34.17 130.04,33.86 PR69.2
  BOTTOM w0.127: PR194.2 116.25,29.44
  BOTTOM w0.254: v2(116.29,31.02) 116.36,30.96 116.36,29.55 116.25,29.44
N132058456:
  vias: v1(126.82,27.87)
N132058503: length 3.1
  TOP w0.508: PC65.1 138.38,27.2 v1(138.46,27.28) 138.61,27.43 138.61,28.34 138.35,28.6 PR92.1
N132064940: length 6
  TOP w0.102: PU5.9 173.08,31.22 PR81.1 173.41,31.51 173.78,31.14 174.51,31.14 PC55.2 174.6,31.48 PR77.2 174.6,32.48 173.74,33.34 v1(173.57,33.34)
N132064948: length 109.9
  TOP w0.102: PR32.2 112.76,60.06 111.17,58.47 111.17,57.3 111.36,57.11 PR39.2 110.48,56.64 v2(110.09,56.25) 110.09,55.36 110.97,54.48 PR41.2 ; v1(178.01,31.99) 177.95,31.99 177.57,31.61 PR86.2
  TOP w0.152: PR86.2 177.57,30.54 177.36,30.33 v2(177.3,30.33) 178.02,29.61 PD3.1
  IN3 w0.114: v2(117.84,31.36) 117.84,30.36 118.12,30.09 122.41,30.09 122.79,30.47 126.14,30.47 126.6,30.93 145.72,30.93 146.24,30.42 146.24,28.38 147.33,27.29 154.08,27.29 154.82,28.03 154.82,29.53 156.29,31 160.94,31 162.67,32.73 174.91,32.73 v2(177.3,30.33)
  BOTTOM w0.102: v2(117.84,31.36) 117.84,31.86 115.68,34.02 114.92,34.02 109.2,39.74 109.2,44.84 109.86,45.5 109.86,54.22 110.09,54.44 v2(110.09,56.25)
N132064968: length 14.5
  TOP w0.102: v1(174.91,33.36) 175.38,32.9 PR77.1 175.38,31.48 PC55.1 175.38,31.23 175.38,30.12 v2(174.94,29.68)
  IN3 w0.127: v2(174.94,29.68) 174.87,29.61 166.51,29.61 v2(165.79,28.89)
  BOTTOM w0.102: PR195.1 v2(165.79,28.89)
N132065111: length 2.5
  BOTTOM w0.508: v1(167.39,23.02) PC182.2 165,23.02 PR200.1
N132066969: length 4.7
  BOTTOM w0.102: v1(212.53,119.65) 212.47,119.7 PR147.1
  BOTTOM w0.203: PU8.9 209.27,121.56 210.11,120.72 PR140.2 211.3,119.94 PR147.1
N132066980: length 26.8
  TOP w0.127: PR8.2 184.69,118.88
  TOP w0.254: 184.69,118.88 185.58,117.99 190.43,117.99 193.71,114.72 202.01,114.72 206.26,118.96 v1(206.84,118.96) PR7.1
N132067077: length 3.5
  BOTTOM w0.102: PC98.2 205.11,123.28 204.61,122.77 204.61,121.73 v1(204.86,121.47)
  BOTTOM w0.508: PC98.2 205.13,123.33 PR128.1
N132067106: length 1.3
  BOTTOM w0.508: PC104.1 196.82,122.08 PR135.1
N132067112: length 4
  BOTTOM w0.102: PD6.1 212.73,116.78 v1(212.78,116.78)
  BOTTOM w0.203: PR147.2 210.52,118.81 211.03,118.31 PD6.1
N132067793: length 4.7
  BOTTOM w0.102: PR127.2 v1(170.26,124.41)
  BOTTOM w0.254: PR133.1 169.48,123.26 PU7.6 168.19,124.4 PC89.2 PR127.2
N132067797:
  vias: v1(165.1,120.11)
N132067872: length 3.4
  BOTTOM w0.102: v1(163.72,125.39) PR129.1
  BOTTOM w0.254: PU7.5 165,123.27 PC91.1 163.73,124.41 PR129.1
N132072865: length 4.6
  TOP w0.102: v1(188.65,31.89) 189.6,32.84 PC51.1
  TOP w0.508: PQ10.3 189.6,34.05 PC51.1 PR71.1
N132072905:
  vias: v1(178.42,115.81)
N132073040: length 4.6
  TOP w0.508: PR116.1 PC82.1 235.31,19.15 v1(236.16,20.01) 236.9,20.75 PQ19.3
N132073086: length 3.9
  TOP w0.102: v1(194.57,41.62) 194.7,41.49 PR207.1
  TOP w0.254: PQ9.3 PC37.1 PR207.1
N132077352: length 7.4
  TOP w0.102: PQ8.2 245.12,48.27 245.35,48.04 245.35,47.36 245.08,47.09 PR59.1 245.08,46.38 245.85,45.6 v1(246.57,45.6) 246.87,45.6 248.39,47.13 PD1.3
N132077358: length 6.1
  TOP w0.102: PR57.2 242.47,47.19 v1(241.94,47.71) 241.94,48.35 243.1,49.51 PR50.2 243.38,49.51 244.13,50.25 PQ8.3
N132077583: length 166.9
  TOP w0.102: PR49.1 248.78,51.3 v2(249.16,51.68) 249.26,51.78 250.27,51.78 250.81,51.24 251.67,51.24 v1(252.08,50.84) 252.26,50.66 254.26,50.66 254.82,50.1 254.82,49.44 254.76,49.38 PR191.1 PR188.2 253.75,48.37 PQ41.3 ; v2(215.35,116.01) 216.24,116.9 PQ2.2
  IN1 w0.089: v2(189.85,69.23) 189.52,69.23 189.23,69.51 189.23,70.2 189.44,70.41 189.44,72.05 187.43,74.05 187.43,78.95 190.48,82 190.48,88.4 190.88,88.8 190.88,89.13 190.36,89.66 190.36,97.85 190.61,98.11 191.3,98.11 191.6,98.41 191.6,99.05 192.26,99.71 195.82,99.71 196.2,100.09 196.2,100.77 196.88,101.46 197.44,101.46 199.83,103.85 199.83,104.74 203.11,108.01 204.91,108.01 210.93,114.03 213.37,114.03 v2(215.35,116.01)
  IN2 w0.114: v2(249.16,51.68) 248.55,51.68 247.66,50.79 244.34,50.79 243.57,51.56 243.57,55.52 239.49,59.6 230.44,59.6 227.65,62.39 227.65,67.61 227.65,67.61 227.65,67.8 226.78,68.67 223.25,68.67 221.7,70.22 210.71,70.22 201.77,79.16 199,79.16 198.62,78.77 194.03,74.19 192.81,74.19 192.05,73.42 190.83,73.42 190.1,72.69 190.1,71.97 189.49,71.36 189.49,70.19 189.42,70.12 189.42,69.46 189.64,69.23 v2(189.85,69.23)
  BOTTOM w0.102: PQ34.2 189.71,68.46 189.85,68.6 v2(189.85,69.23) ; v2(215.35,116.01) 215.35,115.96 216.42,117.03 PQ27.2
N132077598: length 5.3
  TOP w0.102: PD7.2 260.53,47.73 PC158.2 258.92,47.73 258.78,47.87 258.78,48.2 258.47,48.51 PR190.1 257.78,48.51 257.59,48.32 257.59,47.87 257.44,47.71 PQ41.2
N132077614: length 4.9
  BOTTOM w0.102: PR179.2 195.19,59.95 v1(194.78,60.36)
  BOTTOM w0.508: PQ37.3 195.72,56.98 195.19,57.51 PR179.2
N132077668: length 6.8
  TOP w0.102: PQ18.2 v1(90.89,21.22)
  TOP w0.508: PR105.2 PC79.2 88.44,23.24 PD4.2 89.09,22.74 PQ18.2
N132077791: length 5.8
  TOP w0.508: v2(188.04,68.01) 187.49,68.01 187.17,67.7 PR29.2
  BOTTOM w0.102: v1(188.64,65.48) 188.64,65.77 187.08,67.32 PQ34.3
  BOTTOM w0.508: v2(188.04,68.01) 187.28,68.01 PQ34.3
N132078025: length 4
  BOTTOM w0.102: v1(232.62,70.6) 231.61,71.61 PR175.2
  BOTTOM w0.508: PQ33.3 229.07,71.61 PR175.2
N132078232: length 0.9
  TOP w0.102: 212.48,119.06 v1(212.48,120)
N132189519: length 7
  TOP w0.102: v1(228.81,57.31) 228.81,57.47 229.43,58.09 231.07,58.09 PR35.2
  TOP w0.279: PU1.18 232.9,54.93 232.89,54.94 232.89,55.17 232.68,55.37 232.3,55.37 232.02,55.65
  TOP w0.635: 232.02,55.65 231.92,55.76 231.92,57.24 PR35.2
N132189535: length 4.4
  TOP w0.254: PU1.4 234.4,49.62 234.48,49.54 234.48,48.73 PR52.2 234.38,48.63 PR58.1 235.17,46.81 PR60.1
N132189539: length 6.6
  TOP w0.102: v1(240.2,49.01) 239.78,49.42 239.78,50.51 PR48.1
  TOP w0.254: PU1.7 237.35,51.39 237.71,51.03 PC34.1 238.24,51.04 PR46.2 240.27,51.04 PR48.1
N132189541: length 6.6
  TOP w0.102: v1(237.68,45.78) 237.35,46.11 237.35,47.51 236.9,47.95 236.9,48.34 236.73,48.51 PR55.1
  TOP w0.254: PU1.5 234.9,49.91 235.04,49.77 235.8,49.77 236.35,49.22 PR55.1
N132189548: length 6.9
  TOP w0.102: PC26.1 235.58,56.82 235.01,57.39 235.01,58.63 235.16,58.79 v1(236.58,58.79)
  TOP w0.279: PR34.1 234.4,56.62 PU1.15
  TOP w0.381: PC26.1 235.57,56.63 PR34.1
N132189552: length 8
  TOP w0.102: v1(241.63,49.1) 241.3,49.42 PR47.2
  TOP w0.254: PR56.1 239.26,47.17 239.95,47.17 240.87,48.09 240.87,49.18 240.3,49.75 240.3,50.23 PR48.2 240.3,50.25 PR47.2
N132189562: length 31.3
  TOP w0.254: v2(213.73,59.65) 214.64,58.74 v1(228.07,58.74) 228.12,58.78 232.25,58.78 232.42,58.61 233.18,58.61 233.36,58.79 234.6,58.79 234.93,59.12 235.39,59.12 235.75,59.47 236.91,59.47 238.1,58.28 PR37.1 237.32,56.68 PC27.1 236.17,55.85 235.89,55.85 235.4,55.36 PU1.13
  BOTTOM w0.254: PR177.2 213.72,59.66 v2(213.73,59.65)
N132189566: length 4.7
  TOP w0.254: PR54.2 233.12,46.78 233.34,47 233.34,47.42 233.24,47.53 PC254.1 233.58,47.81 233.9,48.13 PU1.3
N132189568: length 7.3
  TOP w0.254: PU1.14 234.9,55.8 v2(234.96,55.87)
  BOTTOM w0.102: PR178.2 233.8,59.53 233.94,59.68 v1(234.6,59.68)
  BOTTOM w0.254: PR178.2 234.18,58.79 234.33,58.63 234.33,58.1 233.8,57.56 PR181.2 234.51,57.09 234.96,56.64 v2(234.96,55.87)
N132189576: length 5.1
  TOP w0.102: v1(237.93,47.1) 237.55,47.48 PR56.2
  TOP w0.254: PU1.6 235.4,50.25 235.5,50.14 236.62,50.14 237.55,49.21 PR56.2
N132189624: length 2.7
  TOP w0.102: PR51.1 239.13,48.42 239.5,48.05 v1(239.5,47.8)
  TOP w0.254: PR51.1 239.13,50.13 PR46.1
N132189878: length 2.9
  TOP w0.102: PC28.2 v1(228.74,55.61)
  TOP w0.635: PC28.2 229.99,57.15 PR35.1
N132189916: length 2.4
  TOP w0.254: PR42.1 238.09,52.94 237.65,52.94 237.1,52.39 PU1.9
N132189952: length 2.9
  TOP w0.254: PU1.1 232.9,50.07 232.32,49.49
  TOP w0.635: 232.32,49.49 231.75,48.93 PR53.2
N132189956: length 3.3
  TOP w0.102: v1(228.44,49.35) 228.57,49.48 229.15,49.48 229.37,49.7 PC35.2
  TOP w0.635: PC35.2 229.96,49.69 PR53.1
N132190007: length 10.7
  TOP w0.102: PC32.1 243.24,52.3 v1(243.48,52.06)
  TOP w0.254: 242.04,52.18 242.04,51.88 v2(241.77,51.6) ; 242.04,52.18 PR44.2 ; 242.04,52.18 242.41,52.18 PC32.1
  BOTTOM w0.254: PR192.2 238.44,46.22 238.56,46.34 PC166.2 239.46,46.34 240.65,47.53 240.65,50.48 v2(241.77,51.6)
N132190113: length 2.1
  TOP w0.102: v1(241.25,54.19) 240.17,54.19 PC30.1
  TOP w0.254: PC30.1 240.16,54.23 PR40.1
N132190141: length 2.3
  TOP w0.102: PC32.2 242.97,53.08 243.38,53.49 v1(243.52,53.49)
  TOP w0.254: PC32.2 242.42,53.19 PR43.2
N132190211: length 2.9
  BOTTOM w0.102: v1(230.13,50.79) PC150.2
  BOTTOM w0.508: PR184.1 228.99,51.63 228.89,51.52 228.89,50.79 PC150.2
N132190437: length 3.1
  BOTTOM w0.102: PR186.1 200.54,52.41 200.36,52.59 199.95,52.59 v1(199.55,52.99)
  BOTTOM w0.508: PR186.1 200.64,51.73 PC153.2
N132285438: length 5.4
  TOP w0.102: Q24.5 285.46,32.75 285.29,32.93 285.29,33.22 285.46,33.4 Q24.6 287.4,33.4 v1(287.64,33.64) 288.02,34.02 R220.2
N132286840: length 3.3
  TOP w0.102: v1(294.62,30.09) R260.2
  TOP w0.254: U12.4 293.84,27.89 293.98,28.03 293.98,28.31 R260.2
N132286842: length 5.7
  TOP w0.102: v1(298.28,28) 297.98,27.7 296.69,27.7 296.57,27.57 C358.2
  TOP w0.254: R260.1 294.62,27.57 295.61,26.58 296.27,26.58 296.57,26.88 C358.2
N132286847: length 5.2
  TOP w0.102: U12.3 294.18,27.24 R272.2 294.11,26.28 294.11,25.5 294.55,25.06 v1(294.55,23.74)
N132286854: length 2.8
  TOP w0.102: R272.1 294.89,25.75 294.89,25.11 C394.2 295.87,24.13 v1(295.87,23.71)
N132292966: length 4.4
  BOTTOM w0.102: v1(126.09,115.25) 126.14,115.3 126.14,117.59 124.98,118.76 124.98,119.16
N132293008: length 6.1
  TOP w0.102: v1(116.5,122.27) 116.15,122.27 115.8,121.91 PR2.2
  TOP w0.203: PC6.1 116.2,118.09 116.09,117.97 PR10.1 PR6.1 115.56,119.89 PR3.2 PR2.2
N132293024: length 4.1
  BOTTOM w0.102: 141.46,122.82 141.46,124.93 142.4,125.87 v1(143.04,125.87)
N132293060: length 4.1
  BOTTOM w0.102: v1(105.19,122.67) 105.27,122.74 105.82,122.74 106.7,121.86 106.7,120.94 PR139.2
  BOTTOM w0.254: PR139.2 106.7,120.69 PC108.1
N132293090: length 8.4
  BOTTOM w0.102: v1(105.6,109.08) 105.27,109.41 105.27,110.45 106.1,111.29 106.1,111.72 106.49,112.11 PR167.1
  BOTTOM w0.178: PU9.15 110.09,114.15 110.09,113.63 109.08,112.61 108.21,112.61 PR169.1
  BOTTOM w0.203: PR167.1 106.62,112.1 PR169.1
N132293105: length 18.1
  IN1 w0.254: v2(117.08,114.62) 117.28,114.62 118.35,115.68 118.35,121.75 120.4,123.81 121.8,123.81 122.49,124.5 124.16,124.5 v2(124.39,124.73)
  BOTTOM w0.102: v1(124.6,125.72) 124.54,125.67 124.54,124.85 124.42,124.73 v2(124.39,124.73)
  BOTTOM w0.191: PQ24.1 124.26,124.6 v2(124.39,124.73)
  BOTTOM w0.254: v2(117.08,114.62) 116.74,114.62 116.3,115.05 PR161.2
N132293107: length 2.6
  BOTTOM w0.102: PC90.2 v1(117.48,124.67)
  BOTTOM w0.508: PC90.2 118.52,124.03 PR131.2
N132293124: length 3.3
  BOTTOM w0.102: v1(119.77,125.67) 119.3,125.19 PC90.1
  BOTTOM w0.191: PC90.1 120.18,123.79 PQ24.7
N132293126: length 3.2
  BOTTOM w0.102: PR131.1 119.26,123.38 v1(118.25,122.36)
  BOTTOM w0.191: PR131.1 119.35,123.39 PQ24.6
N132293132: length 49.1
  TOP w0.203: v2(106.94,115.51) 106.52,115.93 PR206.2
  TOP w0.254: v1(133.23,124.95) 133.23,125.44 v2(132.9,125.77)
  IN3 w0.203: v2(132.9,125.77) 132.75,125.92 117.81,125.92 116.14,124.24 114.13,124.24 114.13,124.24 114,124.24 111.7,121.94 111.04,121.94 110.78,121.68 108.77,121.68 105.9,118.81 105.9,116.6 106.41,116.09 106.76,116.09 106.94,115.91 v2(106.94,115.51)
  BOTTOM w0.203: v2(132.9,125.77) 132.55,125.42 PR125.1 132.55,124.58 132.06,124.09 130.79,124.09 129.93,123.23 129.93,121.37 130.46,120.84 PL4.4 ; v2(106.94,115.51) 106.71,115.28 105.79,115.28 PR160.2 PC119.2 106.6,116.01 107.25,116.01 PC118.2
N132293163: length 4
  BOTTOM w0.254: v1(124.29,114.92) 124.93,115.56 PR158.1
  BOTTOM w0.508: PR158.1 124.93,117.6 PC111.2
N132293211: length 3.3
  BOTTOM w0.102: v1(131.63,126) 131.63,125.15 PR125.2
  BOTTOM w0.203: PR121.2 129.79,125.1 129.98,124.9 131.67,124.9 PR125.2
N132293406: length 32.5
  TOP w0.102: v1(116.29,113.58) 116.62,113.91 v2(117.08,113.91)
  IN1 w0.254: v2(117.08,113.91) 117.33,113.65 119.9,113.65 120.4,114.16 121.22,114.16 121.57,114.51 121.65,114.59 138.41,114.59 139.35,115.53 142.71,115.53 143.65,116.47 143.95,116.47 144.86,117.38 v2(144.86,117.36)
  BOTTOM w0.191: PQ26.1 145.02,117.92 144.86,117.77 v2(144.86,117.36)
  BOTTOM w0.254: PR163.2 116.95,114.03 v2(117.08,113.91)
N132293412: length 2.7
  BOTTOM w0.102: PC114.2 150.35,116.06 v1(150.35,115.84)
  BOTTOM w0.508: PC114.2 151.42,117.12 151.42,117.89 PR155.2
N132293428: length 5.1
  BOTTOM w0.102: v1(149.31,114.95) 149.51,115.15 149.51,116 PC114.1
  BOTTOM w0.191: PQ26.7 149.11,118.32 149.31,118.12 149.31,117.46 149.82,116.95 150.16,116.95 PC114.1
N132293430: length 3
  BOTTOM w0.191: PR155.1 149.94,118.15 149.94,118.96 v1(150.07,119.09) 150,119.16 149.54,119.16 149.09,118.72 PQ26.6
N132293475: length 3.2
  BOTTOM w0.508: PR120.1 145.37,125.59 145.07,125.28 v1(145.07,124.9) 145.4,124.57 PC95.2
N132293523: length 2.3
  BOTTOM w0.102: PR119.2 134.3,126.1 v1(134.12,125.92)
  BOTTOM w0.203: PR126.2 135.31,125.26 PR119.2
N132294519: length 5.3
  BOTTOM w0.178: PU9.16 109.7,113.74 109.13,113.17 v1(108.52,113.17) 108.09,113.17 107.5,112.58 105.94,112.58 PR168.2
N132294702: length 4.9
  BOTTOM w0.102: v1(117.31,115.33) 116.44,115.33 116.16,115.61 115.24,115.61 115.07,115.77 PR159.1
  BOTTOM w0.178: PR159.1 114.9,116.36 PU9.4
N132313959: length 46.1
  TOP w0.102: PC41.1 48.14,37.32 v1(47.94,37.32)
  TOP w0.254: PR62.2 49.18,34.34 PC44.1 49.5,34.9 v2(50.02,35.42) 49,36.44 PC41.1
  BOTTOM w0.152: PR201.1P 36.3,18.58 37.96,18.58 38.03,18.66
  BOTTOM w0.254: v2(50.02,35.42) 51.27,34.17 52.87,34.17 54.87,32.17 54.87,26.76 57.01,24.62 57.01,21.7 53.09,17.79 39.3,17.79 38.44,18.66 38.03,18.66
N132314015: length 3.6
  TOP w0.508: PR103.1 42.4,21.96 v1(41.77,21.32) 41.74,21.3 PD5.1
N132314297: length 9.1
  TOP w0.102: v2(22.82,88.19) v1(23.54,88.19)
  TOP w0.254: v2(22.82,88.19) 22.82,87.94 PC16.1
  BOTTOM w0.254: PQ31.4 v2(22.82,88.19)
  BOTTOM w0.381: PQ32.4 20.3,89.03 20.3,90.63 PC138.2 20.41,90.96 PR173.2 PR174.1 22.74,89.65 PQ31.4
N132314323: length 4.7
  TOP w0.102: v1(23.41,85.11) PR25.2
  TOP w0.254: PR26.2 21.69,83.74 PQ6.6 ; PR26.2 23.42,83.74 PR27.2 ; PR26.2 22.29,85.1 PR25.2
N132314464: length 7.8
  BOTTOM w0.102: v1(19.16,94.14) 19.64,93.66 23.21,93.66 23.77,93.1
  BOTTOM w0.381: PQ31.2 23.77,93.1 23.95,93.28 24.42,93.28 24.72,92.98 PQ31.1
N132314499: length 12.9
  TOP w0.254: PR24.2 PR23.1 18.42,88.82 PQ5.3
  TOP w0.508: PR24.2 17.15,87.95 17.46,87.64 v2(17.7,87.64)
  IN1 w0.508: v2(17.7,87.64) 17.76,87.64 19.36,89.24 22.18,89.24 23.13,90.19 v2(23.13,90.84)
  BOTTOM w0.376: PQ31.5 23.77,90.45
  BOTTOM w0.381: v2(23.13,90.84) 23.38,90.84 23.77,90.45
N132314535: length 2
  TOP w0.254: PU3.9 50.63,28.79 PR70.1
N132314688: length 4.9
  TOP w0.102: v1(19.16,80.91) PC17.1
  TOP w0.254: 20.73,82.11 20.73,81.3 PR28.2 ; 20.73,82.11 20.68,82.06 PC17.1 ; 20.73,82.11 PQ6.5
N132314783: length 3.4
  TOP w0.102: PC16.2 v1(19.46,87.34)
  TOP w0.254: PC16.2 20.08,86.67 PQ6.3
N132314788: length 1.9
  TOP w0.102: PR22.2 v1(23.74,91.66)
N132314800: length 1.8
  TOP w0.254: PR83.1 51.1,28.29 PU3.8
N132314870: length 45.5
  TOP w0.102: v1(51.37,35.01) 51.19,35.01 v2(50.78,35.42)
  TOP w0.254: PR63.1 50.4,34.54 PC44.2 50.28,34.92 v2(50.78,35.42) 50.27,35.93 PC40.1
  BOTTOM w0.152: PR201.2P 36.3,18.27 37.93,18.27
  BOTTOM w0.254: v2(50.78,35.42) 51.67,34.53 53.07,34.53 55.23,32.37 55.23,27.04 57.39,24.88 57.39,21.58 53.2,17.39 39.1,17.39 38.21,18.27 37.93,18.27
N132314886: length 4.7
  TOP w0.102: PR72.2 42.65,30.42 42.25,30.82 v1(42.25,31.38)
  TOP w0.254: PR72.2 42.65,27.69 PC54.2
N132314946:
  vias: v1(32.77,56.65)
N132314996: length 1.3
  BOTTOM w0.254: PR193.2 PR111.2
N132315026: length 4.6
  BOTTOM w0.102: v1(31.2,54.85) 31.2,55.64 30.53,56.3 PR182.1
  BOTTOM w0.254: PQ35.4 30,58.32 30.57,57.75 PR180.2 30.57,56.88 30.44,56.75 PR182.1
N132315143:
  vias: v1(39.96,18.81)
N132315213: length 2.6
  TOP w0.102: v1(34.97,30.19) PC56.2
  TOP w0.508: PC56.2 34.97,32.18 PR68.1
N132315899: length 4.7
  TOP w0.102: v1(33.94,26.1) 34.87,26.1 PQ17.6
  TOP w0.203: 35.07,27.55 PQ17.6 ; 35.07,27.55 35.09,27.53 PR97.2 ; 35.07,27.55 PR95.1
  TOP w0.254: PR97.2 36.11,28.55 PR93.1
N132315907: length 4
  TOP w0.102: PR97.1 37.48,27.53 38.03,28.08 v1(38.03,28.51)
  TOP w0.254: PR97.1 36.89,27.18 36.71,27 35.88,27 35.72,26.84 PQ17.5
N132315919: length 11
  TOP w0.254: v2(34.93,29.2) 35.33,29.6 v1(37.17,29.6) 37.17,28.82 PR93.2 ; v2(34.93,23.68) 35.35,23.68 35.72,24.05 PQ17.2
  IN1 w0.254: v2(34.93,29.2) 34.93,23.54 34.93,23.53 v2(34.93,23.68)
N132315927: length 4.2
  TOP w0.102: 34.95,22.22 34.43,22.22 v1(33.99,21.78)
  TOP w0.254: PR114.1 34.95,22.22 34.43,22.74 34.43,23.86 35.07,24.5 PQ17.1
N132315989: length 3
  TOP w0.254: PU3.11 48.73,30.19 49,30.47 PR64.2
N132479764: length 7.5
  BOTTOM w0.076: U14.J62 122.16,96.79 121.75,96.38 121.39,96.38 121.14,96.13 119.54,96.13 117.92,97.75 116.16,97.75
  BOTTOM w0.102: 116.16,97.75 116.04,97.75 TP60.1
N132479767: length 5.9
  BOTTOM w0.076: TP61.1 118.14,97.04 119.41,95.76 121.75,95.76 122.04,96.06 U14.K62
N132479770: length 7.4
  BOTTOM w0.076: U14.E61 122.49,99.41 122.04,99.41 122.03,99.43 120.58,99.43 120.14,99.87 117.64,99.87 117.64,99.86
  BOTTOM w0.102: TP58.1 116.13,99.88 117.63,99.88 117.64,99.86
N132479773: length 7.3
  BOTTOM w0.076: 116.16,98.31 116.21,98.26 116.21,98.16 116.42,97.95 119.85,97.95 119.92,98.03 120.31,98.03 120.58,98.3 U14.F63
  BOTTOM w0.102: 116.16,98.31 115.56,98.91 TP59.1
N133154508: length 8.2
  BOTTOM w0.102: PR123.1 138.75,125.84 v1(138.97,125.84)
  BOTTOM w0.203: PL3.3 140.14,120.84 139.84,121.14 139.84,122.24 137.93,124.14 PR123.1
N133154903: length 8.4
  BOTTOM w0.102: PR122.1 128.04,125.56 127.59,125.56 v1(127.03,126.12)
  BOTTOM w0.203: PL4.3 129.19,120.84 129.52,121.17 129.52,123.15 128.49,124.18 128.49,125.08 PR122.1
N133155498: length 4
  TOP w0.102: v1(64.15,21.69) PR426.2
  TOP w0.254: PQ50.6 62.45,20.45 62.59,20.31 PC240.1 PR426.2
N133155504: length 4.2
  TOP w0.102: v1(62.16,17.77) PR427.1
  TOP w0.254: PR427.1 PC240.2 63.2,19.06 62.47,19.8 PQ50.5
N133155524: length 3
  TOP w0.102: PQ901.1 v1(61.68,23.72)
  TOP w0.254: PD8.2 PQ901.1
N133155526: length 6.2
  TOP w0.102: PQ901.3 v1(61.7,21.72)
  TOP w0.254: PQ901.3 58.85,21.72 58.15,21.02 PR425.1 58.54,19.8 PQ50.2
N133155528: length 2.6
  TOP w0.102: PR424.2 57.13,22.95 v1(57.41,22.67)
  TOP w0.254: PQ901.2 57.14,23.72 PR424.2
N133159595:
  vias: v1(30.72,15.3)
N133161663: length 4.6
  TOP w0.102: PR428.2 52.31,20.66 52.76,20.2 v1(52.76,18.83)
  TOP w0.254: PQ21.2 PC241.1 PR428.2
N133194593: length 2.8
  TOP w0.102: v1(105.7,44.13) 105.7,43.89 R481.2 104.85,43.4 Q44.3
N133195216:
  vias: v1(103.87,47.99)
N134397230: length 3.3
  TOP w0.102: U7.37 268.24,46.05 v1(268.28,46.09) 268.64,45.73 U7.36
N134397236: length 3.9
  TOP w0.102: v1(265.84,45.99) 265.84,44.32 266.24,43.92 U7.1 265.78,43.7 265.66,43.58 265.66,43.4 265.77,43.3 U7.2
N134397258: length 1.5
  TOP w0.102: U7.13 267.84,38.83 268.02,38.65 268.14,38.65 268.24,38.76 U7.14
N134549402: length 4.4
  TOP w0.254: PR432.2 PR434.2 248.18,40.11 v1(248.04,40.25) 247.74,40.55 PU11.4
N134912471: length 4.9
  TOP w0.102: R504.1 247.62,29.96 249.01,29.96 v1(249.72,30.67) 250.05,30.67 250.6,30.11 U25.10

## Copper pours and planes (outline as drawn)
3V3AUX on TOP (solid shape): 54.64,42.02 54.64,40.91 54.95,40.6 54.95,38.87 55.05,38.77 56.14,38.77 56.17,38.75 56.17,38.62 56.14,38.59 54.97,38.59 54.96,38.58 54.7,38.58 54.06,39.23 53.37,39.23 53.22,39.38 53.22,39.72 53.37,39.86 53.43,40.05 53.37,40.25 53.22,40.39 53.22,41.97 53.37,42.12 54.54,42.12
3V_LGATE2 on TOP (solid shape): 129.85,26.96 129.85,26.61 129.83,26.59 129.65,26.59 129.55,26.49 129.55,25.98 129.4,25.83 128.46,25.83 128.36,25.93 128.36,26.41 128.79,26.84 128.79,26.94 128.82,26.98 129.83,26.98
3V_LGATE2 on BOTTOM (solid shape): 121.88,21.36 121.88,20.59 121.8,20.52 120.32,20.52 120.25,20.59 120.25,21.07 120.74,21.56 121.68,21.56
3V_LGATE2 on IN3 (solid shape): 129.65,26.38 129.65,25.26 129.24,24.85 128.41,24.85 127.92,25.34 127.92,25.92 128.51,26.5 129.52,26.5
3V_LGATE2 on IN3 (solid shape): 123.05,21.2 123.05,20.43 122.92,20.31 120.38,20.31 120.25,20.43 120.25,21.2 120.38,21.32 122.92,21.32
3V_PHASE2 on TOP (solid shape): 129.86,27.44 129.86,27.24 129.82,27.2 128.74,27.2 128.1,26.56 127.67,26.56 127.6,26.64 127.6,26.77 128.3,27.47 129.83,27.47
3V_PHASE2 on BOTTOM (solid shape): 117.2,25.39 117.2,24.78 117.43,24.55 119.67,24.55 119.85,24.37 119.85,23.86 120.12,23.58 120.12,21.13 119.57,20.57 117.36,20.57 117.03,20.24 117.03,19.07 117.31,18.79 118.27,18.79 118.52,18.55 118.52,16.93 118.27,16.68 115.28,16.68 114.39,17.57 114.39,22.86 116.19,24.66 116.19,25.39 116.31,25.51 117.08,25.51
3V_UGATE2 on TOP (solid shape): 129.88,27.95 129.88,27.73 129.85,27.7 128.17,27.7 127.49,27.02 127.34,27.02 127.11,27.25 127.11,27.38 127.71,27.98 129.85,27.98
3V_UGATE2 on BOTTOM (solid shape): 118.58,20.01 118.58,19.25 118.45,19.12 117.36,19.12 117.36,20.04 117.49,20.16 118.43,20.16
3V_UGATE2 on IN3 (solid shape): 128.35,27.93 128.35,27.52 127.59,26.76 127.21,26.76 126.88,27.09 126.88,27.49 127.47,28.08 127.8,28.08 127.82,28.1 128.18,28.1
3V_UGATE2 on IN3 (solid shape): 118.7,20.64 118.7,19.67 118.47,19.44 117.31,19.44 117.23,19.52 117.23,20.08 117.33,20.18 117.81,20.18 117.92,20.28 117.92,20.61 118.04,20.74 118.6,20.74
3VGFX_OND on TOP (solid shape): 220.94,121.7 220.94,119.54 220.84,119.44 220.84,118.38 220.76,118.3 219.95,118.3 219.82,118.43 219.82,119.72 219.72,119.82 218.58,119.82 218.4,120 218.4,121.65 218.65,121.91 220.73,121.91
3VGFX_OND on BOTTOM (solid shape): 221.01,120.99 221.01,119.7 220.91,119.59 219.46,119.59 219.34,119.72 219.34,120.97 219.49,121.12 220.89,121.12
