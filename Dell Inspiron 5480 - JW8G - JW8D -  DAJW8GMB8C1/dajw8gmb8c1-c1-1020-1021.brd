# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PVCC2: length 9.1
  TOP w0.102: v1(285.71,30.44) 285.71,30.31 285.15,29.75 285.15,28.54 C343.2
  TOP w0.356: U12.6 288.85,27.24 C351.1
  TOP w0.508: C351.1 C350.2 285.87,27.81 C343.2 284.43,27.82 R253.2
PVDD1: length 9.7
  TOP w0.305: C257.1 309.18,41.3 309.18,40.22 308.97,40.02 308.97,39.71 308.06,38.79 U10.39
  TOP w0.508: C257.1 308.25,41.03 v1(307.25,41.03) 306.41,41.03 306.08,41.36 C255.2 305.95,42.28 304.79,42.28 L12.2
PVDD2: length 7.1
  TOP w0.305: C261.1 303.14,40.37 304.17,40.37 v1(304.27,40.27) 304.71,40.27 305.06,39.91 305.06,39.3 305.06,39.29 U10.45
  TOP w0.508: L13.2 300.18,40.14 C263.2 301.57,40.36 C261.1
V5FILT: length 17.4
  TOP w0.203: v2(175.75,29.4) 175.26,28.91 PU5.6 ; v2(168.79,25.74) 168.02,26.5 PR99.1 167.48,26.4 v1(167.48,26.02) ; PU5.14 170.01,28.41 169.85,28.56 169.85,28.81 v2(169.56,29.1) PC59.1 168.8,30.13 168.88,30.21 PR88.2
  IN3 w0.203: v2(175.75,29.4) 175.46,29.1 v2(169.56,29.1) 169.78,28.88 169.78,28.05 168.79,27.06 168.79,27.06 v2(168.79,25.74)
VCCSENSE: length 39.3
  TOP w0.254: v2(118.91,99.12) 118.83,99.05 118.64,99.05 115.49,102.2 114.5,102.2 108.25,108.44 106.03,108.44 105.32,109.15 105.32,117.88 v1(105.73,118.29) 106.43,118.99 106.43,121.39 v2(105.69,122.13)
  BOTTOM w0.254: U14.E63 120.45,99.09 120.02,98.67 119.39,98.67 119.11,98.94 119.08,98.94 v2(118.91,99.12) 118.91,99.14 118.57,99.48 R304.1 ; v2(105.69,122.13) 106.07,121.75 106.07,120.53 106.15,120.45 106.15,119.44 106.65,118.94 PR152.1
VCCST_PWRGD#: length 277.9
  TOP w0.102: Q6.2 124.21,114.57 124.32,114.46 124.32,113.35 v2(124.09,113.12)
  IN1 w0.089: v2(91.6,60.16) 93.2,58.56 100.52,58.56 103.56,61.61 103.56,68.74 102.55,69.76 102.55,85.86 104.81,88.12 104.81,97.78 112.15,105.12 116.16,105.12 120.28,109.23 120.36,109.23 123.5,112.37 123.5,112.53 v2(124.09,113.12)
  IN2 w0.114: v2(91.6,60.16) 97.9,53.86 97.9,33.87 101.18,30.59 v2(101.18,27.27)
  IN3 w0.114: v2(230.23,29.02) 230.66,29.44 232.41,29.44 233.88,27.97 233.88,27.97 234.42,27.43 235.3,27.43 235.57,27.7 236.05,27.7 236.25,27.5 236.25,23.02 235.01,21.78 232.6,21.78 232.24,21.42 230.97,21.42 230.35,22.05 228.79,22.05 228.38,22.05 227.17,20.84 226.7,20.84 226.07,21.47 223.83,21.47 223.58,21.22 211.79,21.22 211.56,21.45 209.09,21.45 207.61,22.92 203.89,22.92 203.44,23.38 202.78,23.38 201.48,24.67 197.59,24.67 194.76,27.51 191.64,27.51 190.46,28.69 188.7,28.69 187.66,29.73 184.92,29.73 180.12,34.53 157.2,34.53 154.57,31.9 147.58,31.9 147.21,32.27 146,33.48 114.48,33.48 110.7,29.7 105.98,29.7 103.46,27.19 101.25,27.19 v2(101.18,27.27)
  BOTTOM w0.102: U23.107 229.89,29.36 v2(230.23,29.02)
VCCST_PWRGD_L: length 14.1
  TOP w0.102: v2(124.71,102.35) 124.71,103 124.98,103.26 124.98,109.64 v1(124.81,109.8) 124.19,110.42 R14.2 123.69,110.85 123.5,111.03 123.5,113.75 Q6.3
  BOTTOM w0.076: 124.6,101.65 124.6,101.44 U14.B59
  BOTTOM w0.102: v2(124.71,102.35) 124.6,102.23 124.6,101.65
VDD10: length 8.8
  TOP w0.203: U6.22 286.67,47.27 286.48,47.08 v2(285.91,47.08) ; U6.30 v2(290.4,44.85) ; U6.8 292.21,49.27 292.36,49.41 292.36,49.59 292.18,49.78 v2(291.9,49.78) ; U6.3 v2(292.94,47.27)
  TOP w0.508: C222.2 C223.2
  BOTTOM w0.508: v2(290.4,44.85) 290.4,45.42 290.64,45.66 291.21,45.66 291.71,46.15 C483.1
  vias: v1(283.17,47.53) v2(282.56,47.87) v2(282.56,47.15) v2(283.07,48.25) v2(283.7,48.25)
VSS_GPU_SENSE: length 100.7
  TOP w0.254: v2(235.75,47.1) 235.76,47.09 235.76,46.3 234.91,45.45 232.62,45.45 231.12,46.95 221.32,46.95 v1(220.42,46.05) 219.54,45.17 201.53,45.17 199.5,47.2 199.5,55.76 195.28,59.99 PR33.1 195.28,60.71 v2(195.51,60.95)
  IN3 w0.254: v2(182.25,87.69) 182.02,87.46 182.02,85.49 181.21,84.68 181.21,82.03 181.48,81.76 181.48,77.1 180.96,76.58 180.96,70.87 178.9,68.81 178.9,64.22 182.18,60.95 v2(195.51,60.95)
  BOTTOM w0.102: v2(182.25,87.69) 182.65,87.3 U13.F1
  BOTTOM w0.254: v2(235.75,47.1) 235.93,47.29 235.93,47.3 236.21,47.59 236.88,47.59 PR189.1
VSSSENSE: length 39.9
  TOP w0.254: v2(105.56,121.37) 105.86,121.07 v1(105.86,120.24) 105.86,119.27 104.91,118.33 104.91,108.99 105.86,108.04 108.09,108.04 114.33,101.79 115.32,101.79 118.47,98.64 118.73,98.64 v2(118.91,98.46)
  BOTTOM w0.203: 121.3,98.69 121.31,98.68 121.79,98.68 U14.E62
  BOTTOM w0.254: PR156.1 106.59,117.74 106.04,118.29 106.04,118.98 105.7,119.32 105.7,120.33 105.65,120.38 105.65,121.28 v2(105.56,121.37) ; R306.1 118.4,98.41 118.42,98.44 118.88,98.44 v2(118.91,98.46) 119.08,98.28 120.13,98.28 120.59,98.75 121.08,98.75 121.14,98.69 121.3,98.69
3DVISION: length 12.9
  BOTTOM w0.102: U13.B6 186.42,83.62 186.42,83.22 185.86,82.66 185.86,82.15 185.3,81.6 180.4,81.6 179.74,80.94 179.15,80.94 178.72,81.37 178.01,81.37 176.94,80.3 TP34.1
8205EN: length 4
  TOP w0.152: PR106.2 127.86,24.3 v1(127.74,24.42)
  TOP w0.279: PU4.13 130.21,25.49 129.81,25.09 PR107.1 129.79,24.3 PR106.2
8207BST: length 1.9
  TOP w0.254: PU5.22 173.08,24.72 v2(173.16,24.63)
  BOTTOM w0.305: PR197.2 173.01,24.79 v2(173.16,24.63)
8207BSTR: length 3.1
  BOTTOM w0.102: v1(170.8,26.96) 171.36,26.39 PC177.1
  BOTTOM w0.305: PR197.1 173.01,26.47 172.88,26.34 172.43,26.34 172.37,26.39 PC177.1
8207CS: length 7
  TOP w0.102: PR99.2 168.8,26.44 169.27,25.97 169.27,25.66 168.95,25.34 166.58,25.34 v1(166.2,24.95)
  TOP w0.203: PU5.16 169.26,27.41 PR99.2
8207DRVH: length 19.1
  TOP w0.279: v3(172.45,24.54) 172.45,24.71 172.58,24.84 PU5.21
  TOP w0.508: v3(157.87,18.69) v1(158.68,18.69)
  IN1 w0.508: v3(172.45,24.54) 172.45,24.21 172.05,23.8 167.18,23.8 162.07,18.69 v3(157.87,18.69)
8207DRVL: length 13
  TOP w1.016: 170.81,25.55 169.94,24.67 169.17,24.67 167.66,23.16 v1(166.01,23.16) 164.49,21.64 164.49,18.34 165.41,17.42 v3(165.87,17.42)
8207LX: length 13.2
  TOP w0.254: v3(171.68,24.58) 172.08,24.98 PU5.20
  TOP w0.508: v1(163.08,22.91) v3(162.24,22.91)
  IN1 w0.508: v3(171.68,24.58) 171.67,24.57 166.68,24.57 165.02,22.91 v3(162.24,22.91)
  BOTTOM w0.508: PC177.2 171.77,24.67 v3(171.68,24.58)
8207S3: length 9.3
  TOP w0.102: PR86.1 176.79,31.84 v1(176.64,31.99)
  TOP w0.152: PD3.2 176.79,29.65 PR86.1 176.17,31.03 175.86,30.72 v2(175.86,30.36) ; PC53.1 172.58,31.15 v2(172.58,30.73) PU5.10
  IN3 w0.152: v2(175.86,30.36) 175.68,30.19 173.12,30.19 v2(172.58,30.73)
8207S5: length 7
  TOP w0.102: v1(168.11,33.77) PR66.1 169.27,33.38 169.48,33.16 170.24,33.16 170.47,32.93 170.47,31.81 170.81,31.47 PR82.1
  TOP w0.152: PR82.1 171.11,31.47 172.08,30.51 PU5.11
8207TON: length 5.7
  TOP w0.102: PR80.2 169.46,31.99 168.11,31.99 v1(167.6,31.48)
  TOP w0.152: PU5.12 171.58,30.37 171.17,30.79 170.33,30.79 169.94,31.19 PR80.2
51622_ALERT#: length 9
  BOTTOM w0.102: PR138.1 116.44,121.01 116.44,120.72 116.34,120.62 115.6,120.62 115.5,120.52 115.5,120.22 115.6,120.11 116.34,120.11 116.44,120.01 116.44,119.34 116.31,119.21 115.05,119.21 114.95,119.32 114.95,119.72 114.85,119.82 114.55,119.82 v1(114.14,119.41) 113.47,118.75 113.47,118.49 113.14,118.16 PU9.32
51622_B-RAMP: length 9.7
  TOP w0.203: PR19.2 106.28,110.81 106.21,110.88 106.21,112.03 106.31,112.14 PR16.1 106.98,112.46 107.21,112.46 108.23,113.48 v1(109.79,113.48) 111.4,113.48 v2(111.77,113.12)
  BOTTOM w0.178: PU9.11 111.7,113.19 v2(111.77,113.12)
51622_COMP: length 8.4
  TOP w0.102: v1(107.89,120.26) PR4.2
  TOP w0.254: PR4.2 109.88,120.26 110.03,120.11 v2(110.09,120.11)
  BOTTOM w0.178: PU9.26 110.1,118.62 109.52,119.2 PC109.1
  BOTTOM w0.254: PR143.1 109.52,120.88 109.25,121.14 108.42,121.14 108.09,120.81 PR139.1 ; PR143.1 109.6,120.49 109.76,120.49 110.09,120.15 v2(110.09,120.11) ; PR143.1 PC109.1
51622_CSN1: length 56.8
  TOP w0.254: v1(137.04,125.06) v2(137.04,125.84)
  IN3 w0.203: v2(106.97,114.82) 106.97,114.41 106.79,114.24 106.51,114.24 105.29,115.45 105.29,118.84 108.43,121.98 110.6,121.98 110.88,122.26 111.51,122.26 113.86,124.61 115.97,124.61 117.61,126.25 136.63,126.25 v2(137.04,125.84)
  BOTTOM w0.178: PC125.2 108.46,115.16 PU9.18
  BOTTOM w0.203: v2(106.97,114.82) 105.89,114.82 PR164.2 PC126.2 PC125.2 ; PL3.4 139.1,120.84 139.43,121.17 139.43,122.11 136.9,124.64 136.71,124.64 PR126.1 136.69,125.51 136.71,125.51 v2(137.04,125.84)
51622_CSN2: length 5.6
  TOP w0.203: v2(107.55,115.12) 107.55,116.08 v1(107.35,116.28) 107.03,116.6 106.47,116.6 PR206.1 106.36,117.42 PR13.2
  BOTTOM w0.178: v2(107.55,115.12) 107.93,115.12 108.37,115.56 PU9.19
51622_CSP1: length 52.5
  TOP w0.254: v1(138.49,126.35) v2(137.55,126.35)
  IN3 w0.203: v2(107.07,113.07) 107.07,113.65 106.84,113.88 106.36,113.88 104.96,115.28 104.96,118.96 108.29,122.29 110.45,122.29 110.75,122.59 110.76,122.59 111.39,122.59 113.72,124.93 115.78,124.93 117.42,126.57 137.33,126.57 v2(137.55,126.35)
  BOTTOM w0.178: PC125.1 107.75,113.52 108.09,113.85 108.09,114.24 108.61,114.76 PU9.17
  BOTTOM w0.203: PR123.2 137.94,125.81 137.94,125.96 v2(137.55,126.35) 137.5,126.4 136.39,126.4 PR119.1 ; PC125.1 107.57,113.55 106.57,113.55 PC126.1 PR164.1 105.82,113.07 v2(107.07,113.07)
51622_CSP2: length 40.7
  TOP w0.254: v2(130.39,125.44) 130.16,125.21 v1(129.57,125.21)
  IN3 w0.203: v2(106.94,117.13) 106.94,116.62 106.79,116.47 106.54,116.47 106.26,116.75 106.26,118.65 108.95,121.35 110.9,121.35 111.18,121.63 111.92,121.63 114.16,123.86 116.37,123.86 118.09,125.59 130.23,125.59 v2(130.39,125.44)
  BOTTOM w0.178: PU9.20 108.04,115.96 107.55,116.45 PC118.1
  BOTTOM w0.203: v2(106.94,117.13) 106.12,117.13 PR154.2 105.34,116.56 PR160.1 PC119.1 107.53,116.53 PC118.1 ; PR122.2 PR121.1 130.03,125.88 130.39,125.52 v2(130.39,125.44)
51622_DROOP: length 4.4
  BOTTOM w0.178: PU9.25 109.7,118.49 109.46,118.73 109.1,118.73
  BOTTOM w0.203: PC108.2 108.09,119.77 108.26,119.59 PC109.2 ; PC109.2 PR143.2 ; PC109.2 108.74,119.1 109.1,118.73
51622_F-IMAX: length 9.9
  TOP w0.203: PR20.2 107.78,109.72 107.98,109.92 107.98,110.27 108.19,110.48 108.19,111.98 108.03,112.14 PR17.1 107.68,112.46 107.88,112.66 v1(111.23,112.66) 112.02,112.66 112.43,113.07 v2(112.43,113.14)
  BOTTOM w0.178: v2(112.43,113.14) 112.1,113.47 PU9.10
51622_GFB: length 1.9
  BOTTOM w0.178: PR156.2 108.03,117.74 108.62,117.16 PU9.23
51622_IMON: length 4.7
  BOTTOM w0.102: v1(112.05,112) 111.91,112.14 PR166.1
  BOTTOM w0.178: PU9.13 110.9,113.59 109.84,112.53 PC136.1
  BOTTOM w0.203: PR166.1 PC136.1
51622_O-USR: length 8.5
  TOP w0.203: v2(113.04,113.3) 113.04,113.04 112.29,112.29 112.1,112.29 111.9,112.09 v1(110.02,112.09) 109.6,112.09 109.55,112.14 PR18.1 108.8,112.14 108.57,111.91 PR21.2
  BOTTOM w0.178: PU9.9 112.5,113.84 v2(113.04,113.3)
51622_OCP-I: length 7.5
  BOTTOM w0.102: v1(110.57,109.08) 110.74,109.24 PR170.1
  BOTTOM w0.178: PU9.12 111.3,112.9 111.59,112.61 112.17,112.61 112.25,112.53 112.25,112.52 112.26,112.52 112.57,112.22 112.57,111.78 112.14,111.36 PR166.2
  BOTTOM w0.203: PR170.1 110.74,110.54 110.98,110.78 PR166.2
51622_PWM1: length 39.8
  TOP w0.102: v1(115.6,115.15) 115.55,115.2 v2(114.49,115.2)
  IN1 w0.254: v2(114.49,115.2) 114.44,115.2 116.37,113.27 120.02,113.27 120.5,113.75 121.32,113.75 121.8,114.24 138.57,114.24 139.35,115.02 142.76,115.02 143.71,115.98 144.27,115.98 145.52,117.23 148.32,117.23 v2(148.47,117.38)
  BOTTOM w0.178: v2(114.49,115.2) 114.23,115.2 113.88,115.56 PU9.6
  BOTTOM w0.191: PQ26.8 v2(148.47,117.38)
51622_PWM2: length 16.5
  IN1 w0.254: v2(114.51,115.86) 115.2,115.18 117.2,115.18 117.97,115.94 117.97,121.98 120.76,124.78 121.01,124.78 v2(121.09,124.85)
  BOTTOM w0.178: v2(114.51,115.86) 114.42,115.96 PU9.5
  BOTTOM w0.191: PQ24.8 121.07,124.75 121.09,124.78 v2(121.09,124.85)
51622_SKIP#: length 5.3
  BOTTOM w0.102: PR163.1 115.09,113.66 114.97,113.55 114.38,113.55 114.13,113.3 v1(114.13,113.17)
  BOTTOM w0.178: PU9.7 113.79,115.16 114.3,114.65 114.3,114.32 114.59,114.03 PR163.1
  BOTTOM w0.203: PR161.1 PR163.1
51622_THERM: length 8.9
  BOTTOM w0.102: v1(106.99,109.08) 106.47,109.6 PR172.2
  BOTTOM w0.178: PC137.1 109.03,112.14 110.5,113.6 PU9.14
  BOTTOM w0.203: PR172.2 PR171.1 107.85,110.42 108.16,110.73 109.08,110.73 109.33,110.98 109.33,111.62 108.82,112.13 PC137.1
51622_V5A: length 8.2
  BOTTOM w0.191: PC105.1 111.85,119.65 111.65,119.45 111.54,119.45 110.9,118.8 PU9.28
  BOTTOM w0.254: PR132.1 114.11,123.35 v1(113.95,123.2) 113.93,123.18 113.22,123.18 112.38,122.34 112.38,120.18 112.14,119.94 PC105.1
51622_VCLK: length 11.3
  TOP w0.102: v2(112.99,119.14) 113.17,118.96 v1(113.17,118.45) 113.17,118.15 113.68,117.64 114.21,117.64 114.54,117.97 PR10.2
  BOTTOM w0.102: PU9.31 112.1,118.63 112.56,119.09 112.94,119.09 v2(112.99,119.14) 113.47,119.14 113.65,119.32 113.65,122.06 113.77,122.19 114,122.19 114.13,122.06 114.13,120.42 114.31,120.25 PR142.1
51622_VDIO: length 9.9
  TOP w0.102: v2(114.16,118.35) 114.16,118.55 114.59,118.99 PR6.2 114.78,119.83 v1(114.67,119.94)
  BOTTOM w0.102: PU9.1 113.9,117.56 114.16,117.82 v2(114.16,118.35) 114.16,118.73 114.31,118.88 116.77,118.88 116.87,118.99 116.87,119.42 116.67,119.62 116.67,121.22 116.71,121.26 PR137.1
51622_VDO: length 6.4
  BOTTOM w0.102: v1(117.53,116.85) 117.53,117.2 116.99,117.74 116.06,117.74 115.63,118.17 115.22,118.17 PR153.1
  BOTTOM w0.178: PU9.2 113.88,117.16 114.03,117.31 114.98,117.31 PC113.1
  BOTTOM w0.508: PR153.1 115.09,117.21 PC113.1
51622_VFB: length 2.2
  BOTTOM w0.178: PU9.24 108.8,117.56 107.6,118.76 PR152.2
51622_VR_HOT: length 5.1
  BOTTOM w0.102: v1(113.11,122.19) 113.37,121.93 113.37,120.08 113.23,119.94 PR145.1
  BOTTOM w0.178: PU9.30 111.7,118.86 112.77,119.94 PR145.1
51622_VR_ON: length 9
  BOTTOM w0.102: PR165.1 v1(117.7,112.05)
  BOTTOM w0.178: PU9.8 113.56,114.76 113.7,114.62 113.7,114.16 113.5,113.96 113.5,112.97 113.83,112.64 114.89,112.64 115.2,112.94 117.08,112.94 117.15,113.02 PR165.1
  BOTTOM w0.203: PR162.1 PR165.1
51622_VREF: length 25.5
  TOP w0.102: v2(110.12,119.49) 110.31,119.49 v1(110.76,119.05)
  TOP w0.203: PR4.1 110.11,119.48 v2(110.12,119.49) ; v2(109.18,109.41) 108.71,108.94 PR21.1 PR20.1 PR19.1
  IN3 w0.203: v2(109.18,109.41) 108.72,109.87 108.72,118.53 109.69,119.49 v2(110.12,119.49)
  BOTTOM w0.178: PC107.1 110.79,119.3 110.5,119.01 PU9.27
  BOTTOM w0.203: PC107.1 110.73,119.62 110.24,119.62 v2(110.12,119.49) ; v2(109.18,109.41) 108.69,108.93 108.19,108.93 107.68,108.42 106.7,108.42 106.18,108.93 106.18,109.43 105.69,109.93 PR172.1 105.69,110.44 105.95,110.7 106.22,110.7 106.61,111.1 PR167.2
81172_COMP: length 6.2
  TOP w0.102: v1(241.27,55.56) 241.17,55.67 239.81,55.67 PR40.2
  TOP w0.254: PR40.2 239.25,55.11 PC29.1 236.99,55.11 236.63,54.75 236.63,54.09 236.43,53.89 PU1.12
81172_FB: length 10
  TOP w0.102: v1(243.03,54.69) 243.03,54 242.66,53.63 241.05,53.63 PR43.1
  TOP w0.254: PU1.11 236.78,53.39 236.79,53.4 236.79,53.4 236.87,53.48 236.87,53.48 237,53.61 237,54.1 237.23,54.33 PC29.2 239.26,54.33 PC30.2 240.39,53.19 PR43.1 240.6,53.18 PR44.1
81172_FBRTN: length 10.8
  TOP w0.254: v2(237.75,53.69) 237.55,53.69 237.35,53.49 237.35,53.47 237.22,53.34 237.22,53.33 236.94,53.05 236.94,53.05 236.79,52.9 236.77,52.9 236.76,52.89 PU1.10
  BOTTOM w0.254: PR189.2 238.5,47.23 238.61,47.12 PC166.1 239.94,47.9 v1(239.94,48.53) 239.94,50.61 239.02,51.52 239.02,52.42 v2(237.75,53.69)
81172_HG1: length 26.5
  TOP w0.254: 233.4,49.87 PU1.2
  TOP w0.305: 233.4,49.87 233.4,49.54 v3(233.36,49.54)
  IN1 w0.762: v3(233.36,49.54) 230.67,49.54 224.44,55.76 214.23,55.76 v3(212.88,57.11)
  BOTTOM w0.102: v3(233.36,49.54) v1(232.52,49.54)
  BOTTOM w0.762: PQ40.4 v3(212.88,57.11)
81172_HG2: length 15.8
  TOP w0.279: PU1.17 233.4,55.4 v3(232.82,55.97)
  IN3 w0.762: v3(221.72,52.82) 224.87,55.97 v3(232.82,55.97)
  BOTTOM w0.102: v3(232.82,55.97) v1(231.96,55.97)
  BOTTOM w0.762: PQ38.4 221.19,52.97 221.34,52.82 v3(221.72,52.82)
81172_LG1: length 37.1
  TOP w0.102: v1(228.77,50.77) 228.74,50.79 PR45.1
  TOP w0.279: v3(230.84,51.55) 231.12,51.55 231.47,51.89 PU1.23
  TOP w0.381: v3(230.84,51.55) 230.5,51.89 228.85,51.89 PR45.1
  IN3 w0.762: v3(201.66,50.61) 201.68,50.58 209.84,50.58 211.67,52.41 217.91,52.41 219.74,50.58 223.07,50.58 224.54,52.06 227.92,52.06 228.43,51.55 v3(230.84,51.55)
  BOTTOM w0.762: PQ39.4 201.7,50.57 v3(201.66,50.61)
81172_LG2: length 12.3
  TOP w0.254: PU1.20 231.11,53.39 v3(230.89,53.61)
  IN3 w0.762: v3(222.33,52.03) 223.91,53.61 v3(230.89,53.61)
  BOTTOM w0.102: v3(230.89,53.61) 231.63,53.61 v1(231.66,53.58)
  BOTTOM w0.762: PQ36.4 222.86,52.56 v3(222.33,52.03)
81172_PH1: length 28.1
  TOP w0.279: PU1.24 231.7,51.39 v3(231.05,50.74)
  TOP w0.508: v3(231.05,50.74) 230.41,50.74 PC35.1
  IN2 w0.762: v3(231.05,50.74) 230.41,50.74 226.88,54.27 209.13,54.27 v3(207.55,55.84)
  vias: v1(200.62,54.88)
81172_PH2: length 11.7
  TOP w0.279: 231.15,54.34 231.61,53.89 PU1.19
  TOP w0.508: PC28.1 230.19,54.34 231.15,54.34
  TOP w0.762: v3(222,57.39) 225.26,54.14 v1(226.53,54.14) PC28.1
81172_VREF: length 13.1
  TOP w0.102: v1(242.27,50.79) 242.03,51.03 PR47.1
  TOP w0.254: v2(236.48,55.36) 236.89,55.76 237.63,55.76 238.1,56.24 PR37.2 ; PR47.1 240.71,51.62 238.9,51.62 PC33.1 238.06,51.89 v2(237.68,51.89) PU1.8
  BOTTOM w0.254: v2(237.68,51.89) 236.48,53.08 v2(236.48,55.36)
81172GND: length 9.7
  TOP w0.254: PR52.1 235.16,48.63 v2(235.16,49.29) ; v2(237.55,50.25) PC34.2 238.35,50.13 PR51.2
  TOP w0.381: PC27.2 236.99,57.74 236.63,58.11 PC26.2 235.44,57.97 235.44,57.77 235.75,57.47 236.05,57.47 v2(236.41,57.11)
  TOP w0.508: PR38.2 239.54,57.39 239.61,57.46 v2(239.61,57.67) v1(239.61,58.56) ; v3(239.89,52.31) 239.75,52.18 PC33.2 239.12,53.19 PR42.2
  vias: v2(233.49,53.5) v2(233.49,52.67) v2(233.49,51.78)
+CARD_3V3: length 30.6
  IN3 w1.016: 61.68,40.5 61.68,41.31 60.51,42.48 51.82,42.48 50.4,41.06 50.4,39.48 49.36,38.44 35.64,38.44 35.16,37.96
  vias: v1(34.4,36.39) v2(33.51,38.31) v2(33.5,37.66) v2(33.51,36.99) v2(61.07,38.67) v2(61.07,38.04)
+DC_IN:
  vias: v1(21.75,92.85) v2(19.82,91.62) v2(20.44,91.63)
+DC_IN_SS: length 75.9
  TOP w0.254: v2(23.3,82.13) 23.43,82.26 PR27.1 22.3,82.95 PR26.1
  TOP w0.508: PD5.2 v2(44.28,20.56) ; PR424.1 56.43,24.51 v2(56.27,24.34) ; PR94.1 53.1,23.91 v2(52.85,23.66)
  IN2 w0.508: v2(29.07,60.69) 29.47,60.29 29.47,59.63 40.29,48.8 45.25,48.8 47.94,46.11 47.94,40.55 49.28,39.2 49.28,35.27 50.15,34.4 50.15,29.7 52.14,27.72 52.9,27.72 v2(56.27,24.34)
  IN3 w0.508: 55.1,24.24 55.35,23.99 55.91,23.99 v2(56.27,24.34) ; 55.1,24.24 54.72,23.86 53.05,23.86 v2(52.85,23.66) ; 55.1,24.24 55.1,25.51 54.51,26.1 51.88,26.1 50.78,25.01 50.78,21.83 49.51,20.56 v2(44.28,20.56)
  vias: v1(18.4,74.38)
+DCIN_JACK:
  vias: v1(15.73,95.31)
+DCPSUSBYP: length 1.1
  BOTTOM w0.254: U14.AG20 148.83,86.95 v2(149.21,86.58) 149.58,86.95 U14.AG19
  vias: v1(148.98,85.91)
+DDR_VTT: length 82.3
  TOP w0.203: v2(175.93,26.81) 175.83,26.91 PU5.2
  TOP w0.508: v2(107.68,42.89) 106.14,42.89 R481.1
  IN1 w0.508: v2(117.46,52.11) 117.46,51.42 114.94,48.91 113.55,48.91 111.29,46.65 111.29,45.93 108.24,42.89 v2(107.68,42.89)
  BOTTOM w0.508: 179.28,45.66 179.28,46.29 178.52,47.05 176.23,47.05 174.91,48.37 124.19,48.37 120.61,51.95 117.61,51.95 v2(117.46,52.11)
  vias: v1(179,41.08) v2(179.46,44.89) v2(179.94,38.49) v2(179.99,37.83) v2(180.11,44.72) v3(175.53,24.28) v3(175.65,25.01) v3(176.24,24.09)
+FB_PLLAVDD: length 4.6
  TOP w0.457: C138.1 195.56,87.74 v2(195.46,87.64)
  TOP w0.508: v2(203.28,106.01) v2(203.77,106.49) 204.22,106.95 204.22,107.4
  BOTTOM w0.305: v2(199.63,94.3) 199.63,94.12 199.85,93.9 U13.P22 ; U13.F16 195.06,87.24 v2(195.46,87.64)
  BOTTOM w0.381: v2(199.6,88.61) 199.72,88.61 U13.H22
  vias: v1(204.43,106.16)
+LCDVCC:
  vias: v1(273.66,39.83) v2(270.59,33.56) v2(271.23,33.67) v2(271.86,33.67) v2(272.09,38.31) v2(272.73,38.31) v2(273.36,38.31)
+RTC_1: length 4.5
  TOP w0.508: v2(14.99,7) 14.54,7.45 v1(13.8,7.45) 14.21,7.85 RTCR1.2
  BOTTOM w0.508: v2(14.99,7) 15.43,7.43 RTCBT1.1
+RTC_2: length 3.2
  TOP w0.508: RTCD1.1 15.67,9.39 RTCR1.1 14.26,9.45 14.26,10.45 v1(14.11,10.6)
+RTC_CELL: length 298.8
  TOP w0.508: C155.2 154.1,87.22 154.1,86.62 154.08,86.6 v2(154.08,86.58) ; v2(212.81,30.34) 207.25,30.34 206.38,31.2 206.38,32.96 v2(206.1,33.23) ; v2(162.97,67.35) 162.7,67.35 161.12,65.77 161.12,58.3 157.44,54.62 135.49,54.62 128.76,61.35 121.42,61.35 v1(120.51,60.44) 120.25,60.18 v2(119.62,60.18) ; v2(24.01,7.83) 23.58,8.27 20.73,8.27 19.58,7.11 C401.1 16.64,7.11 RTCD1.3
  IN1 w0.508: v2(99.42,43.92) 101.65,46.15 106.6,46.15 109.33,48.88 110.64,48.88 111.4,49.64 111.99,49.64 115.82,53.48 115.82,53.96 115.82,55.82 118.75,58.76 118.75,59.32 v2(119.62,60.18)
  IN2 w0.508: v2(206.1,33.23) 206.1,35.06 205.46,35.7 203.06,35.7 200.72,38.04 193.28,38.04 191.63,39.69 185.71,39.69 183.35,42.05 181.03,42.05 178.77,44.31 175.88,44.31 174.7,45.49 174.7,48.18 174.18,48.7 172.98,48.7 162.9,58.79 162.9,67.27 v2(162.97,67.35) ; 155.2,79.16 155.79,78.57 155.79,77.43 157.21,76.01 157.21,72.33 v2(157.84,71.69)
  IN3 w0.508: 24.02,11.61 31.54,11.61 32.06,12.13 32.06,12.51 33.71,14.16 33.71,16.57 34.78,17.64 47.33,17.64 47.84,18.15 55.35,18.15 57.13,19.93 63.46,19.93 64.3,19.09 v2(64.3,18.86)
  BOTTOM w0.203: 218.51,32.69 U23.3
  BOTTOM w0.254: U14.AG10 154.48,86.95 154.13,86.6 154.1,86.6 v2(154.08,86.58)
  BOTTOM w0.508: R407.1 v2(157.84,71.69) ; v2(162.97,67.35) 160.1,67.35 158.94,68.52 158.94,70.67 159.65,71.39 v2(159.75,71.39) 159.75,71.87 159.67,71.94 R406.2 R405.2 ; v2(64.3,18.86) 65.38,19.94 72.88,19.94 74.14,21.2 93.84,21.2 97.47,24.83 97.47,32.83 99.42,34.78 v2(99.42,43.92) ; 218.51,32.69 217.98,32.69 217.58,32.29 216.8,32.29 216.4,31.9 C511.2 216.4,30.25 216.06,29.91 213.24,29.91 v2(212.81,30.34)
+SMDDR_VREF_CA: length 12.6
  TOP w0.508: v2(155.18,34.71) 155.2,34.73 v1(156.29,34.73) 157.31,34.73 157.84,35.27 C296.1 ; C296.1 C295.1 156.74,36.08 C292.1 154.81,36.95 R200.1 ; C296.1 R201.2 C297.1 R202.2
  BOTTOM w0.102: JDIM1.126 155.51,35.24 155.18,34.91 v2(155.18,34.71)
+SMDDR_VREF_DQA: length 2.6
  TOP w0.508: R166.1 v2(115.68,43.22)
  BOTTOM w0.381: JDIM1.1 115.61,43.29 v2(115.68,43.22)
  vias: v1(114.87,47.08)
+USB_SIDE0_PWR:
  vias: v1(314.77,64.86) v2(312.15,66.79) v2(312.53,67.42) v2(312.78,66.79) v2(313.16,67.42) v2(313.42,66.79)
+USB_SIDE1_PWR: length 0.1
  TOP w0.102: C167.1 17.1,61.89
  vias: v1(17.25,62.65) v2(15.93,63.94) v2(15.93,63.28) v2(15.96,62.65) v2(15.96,62.01) v3(20.05,62.34)
+USB_SIDE2_PWR: length 1.3
  TOP w0.102: v1(17.1,83.2) 16.74,82.83 16.74,82.03
  vias: v2(16.01,80) v2(16.06,82.08) v2(16.06,81.37) v2(16.06,80.68) v2(22.59,57.26) v2(23.15,58.46) v2(23.17,57.03) v2(23.76,58.3)
+V_VDDQ: length 89.9
  TOP w0.254: PU5.8 v2(173.58,30.74)
  TOP w0.457: R166.2 115.68,49.31 118.45,52.08 118.45,54.77 118.07,55.15 v2(117.43,55.15) 117,55.15 116.31,54.47 116.31,53.71 115.8,53.19 R148.1 114.67,52.44 113.02,52.44 112.3,51.71 112.3,50.51 111.59,49.8 110.71,49.8 R154.1
  TOP w0.508: v2(122.01,63.74) 136.46,63.74 136.76,64.04 ; C300.2 v2(140.44,38.21)
  IN1 w0.508: v2(122.01,63.74) 122.01,59.73 v2(117.43,55.15)
  BOTTOM w0.102: 154.41,34.96 154.91,35.46 JDIM1.124
  BOTTOM w0.254: 168.41,30.9 169.78,30.9 170.21,31.33 172.99,31.33 v2(173.58,30.74)
  BOTTOM w0.356: 147.71,35.32 JDIM1.100 ; JDIM1.81 142.01,46.15 v2(141.84,46.32) ; v2(152.92,34.78) 152.92,34.94 153.11,35.13 JDIM1.118 ; v2(143.82,34.78) 143.82,34.99 144.11,35.27 JDIM1.88 ; v2(145.91,34.76) 145.91,35.09 145.88,35.11 145.88,35.17 145.91,35.19 JDIM1.94 ; v2(143.95,46.52) 143.81,46.38 JDIM1.87 ; 154.41,34.96 v2(154.41,34.73) ; JDIM1.93 v2(145.61,46.25) ; v3(149.18,34.76) 149.51,35.09 JDIM1.106 ; JDIM1.111 151.01,45.94 150.99,45.96 v2(150.99,46.52) 152.26,46.52 152.81,45.96 JDIM1.117 ; JDIM1.112 151.31,35.46 ; v2(142.48,38.04) 142.31,37.87 JDIM1.82 142.31,35.07 142.3,35.06 ; v2(140.19,46.52) 140.21,46.5 JDIM1.75 ; v2(147.46,46.57) 147.51,46.57 147.41,46.47 JDIM1.99 ; v2(140.44,38.21) 140.51,38.15 JDIM1.76 140.51,35.26 140.5,35.24 ; 154.61,46.06 JDIM1.123 ; JDIM1.105 149.21,45.96 v2(149.61,46.37)
  vias: v1(148.2,31.14) v2(152.08,58.38) v2(152.56,60.69) v2(152.56,57.92) v2(153.02,60.21) v2(152.99,57.47) v2(153.45,57.01) v2(153.48,59.75) v2(153.98,59.24) v2(155.61,46.47) v2(179.15,31.53) v2(179.74,30.9) v2(179.79,31.53) v2(180.37,31.1) v3(146.72,34.73) v3(147.61,34.71) v3(147.68,33.92) v3(147.94,29.7) v3(148.06,28.82) v3(148.4,34.73) v3(148.45,30.34) v3(148.47,33.95) v3(148.7,29.32) v3(149.11,33.54) v3(149.21,30.09) v3(149.21,28.69) v3(149.72,29.45) v3(150,34.78) v3(150.22,30.21) v3(150.22,28.69) v3(150.73,29.45) v3(150.83,34.76) v3(151.11,30.21) v3(151.24,28.69) v3(151.57,34.76) v3(151.62,29.45) v3(152,30.21) v3(152.13,28.69) v3(152.64,29.45) v3(152.89,30.21) v3(153.02,28.69) v3(153.63,34.71) v3(153.88,33.84) v3(223.27,70.17) v3(223.38,69.38) v3(223.5,70.98) v3(223.73,71.72) v3(224.19,70.24) v3(224.16,69.35) v3(224.29,71.11) v3(225.03,69.99) v3(225.07,71.82) v3(225.07,71.08) v3(225.89,69.15) v3(226.61,69.18) v3(227.38,69.17)
+V_VDDQ_CPU: length 5.4
  BOTTOM w0.102: U14.AN33 140.16,83.26 v2(139.98,83.26)
  BOTTOM w0.203: v2(130.87,81.88) 130.88,81.87 130.93,81.87 U14.AR48
  BOTTOM w0.254: U14.AP43 134.08,82.87 v2(133.75,82.55) ; U14.AJ31 v2(141.67,86.68) ; v2(138.34,78.47) 138.51,78.65 138.9,78.65 139.29,79.05 U14.AY35 ; U14.AJ33 v2(140.37,86.68) ; v2(137.77,86.68) U14.AJ37
  BOTTOM w0.305: U14.AH26 144.69,86.68 v2(144.27,86.68)
  vias: v1(128.23,75.53) v2(130.87,76.77) v2(131.83,70.39) v2(131.86,77.18) v2(131.86,69.71) v2(132.95,70.95) v2(132.98,70.24) v2(132.98,69.56) v2(133.41,78.12) v2(133.46,71.33) v2(133.59,70.7) v2(133.59,69.99) v2(133.99,71.87) v2(134.15,71.16) v2(135.8,77.71) v2(135.82,77)
+V_VREF_VD1: length 5.8
  TOP w0.102: v1(115.3,50.91) 115.3,50.89 115.02,51.17 113.44,51.17 113.37,51.09 113.37,50.23 113.03,49.89 R152.1
  TOP w0.508: R152.1 113,49.77 C215.2 R158.1
+VCHGR:
  vias: v1(34.86,16.67) v2(35.16,15.86) v2(35.16,15.23) v2(35.16,14.59) v2(35.16,13.96) v2(35.16,13.32) v2(35.8,15.86) v2(35.8,15.23) v2(35.8,14.59) v2(35.8,13.96) v2(35.8,13.32)
+VGACORE: length 4.8
  TOP w0.508: v2(185.91,75.91) 185.86,75.91 185.83,75.93 C187.2 ; C169.2 180.86,80 180.71,80.15 v2(180.71,80.15) ; C175.2 v2(185.89,77.2) ; v2(180.73,79.19) 181.2,78.73 C172.2
  BOTTOM w0.381: U13.K18 198.05,89.9 v2(198.13,89.83)
  BOTTOM w0.508: v2(188.32,70.8) 188.3,70.78 C464.2
  vias: v1(192.64,63.26) v1(197.42,68.01) v2(188.27,90.33) v2(188.43,95.87) v2(188.81,92.14) v2(188.88,97.4) v2(188.88,95.41) v2(188.88,93.48) v2(189.84,92.35) v2(189.9,90.41) v2(190.46,88.96) v2(190.85,97.36) v2(190.89,95.26) v2(190.91,91.41) v2(190.97,93.46) v2(191.93,96.56) v2(191.91,90.41) v2(192.08,98.64) v2(192.29,88.94) v2(192.85,97.37) v2(192.94,95.44) v2(192.93,93.43) v2(192.96,91.46) v2(193.86,96.23) v2(193.94,94.44) v2(193.88,92.38) v2(194.9,97.5) v2(194.85,89.24) v2(195.87,96.28) v2(195.89,94.4) v2(195.89,90.46) v2(195.97,92.44) v2(196.83,93.48) v2(196.93,97.52) v2(197.87,96.4) v2(197.95,98.41) v3(191.35,72.25) v3(191.37,71.51) v3(191.37,70.73) v3(191.37,69.94) v3(191.37,69.18) v3(191.37,68.44) v3(191.37,67.68) v3(191.37,66.92) v3(191.37,66.18) v3(191.37,65.39) v3(191.37,64.63) v3(192.13,72.22) v3(192.11,71.49) v3(192.13,70.73) v3(192.13,69.94) v3(192.13,69.18) v3(192.13,68.44) v3(192.13,67.68) v3(192.13,66.94) v3(192.13,66.15) v3(192.13,65.39) v3(192.13,64.63) v3(192.87,71.46) v3(193.02,72.2) v3(193,70.73) v3(193,69.94) v3(193,69.18) v3(192.97,68.44) v3(192.97,67.68) v3(192.97,66.92) v3(192.97,66.15) v3(192.97,65.39) v3(192.97,64.63) v3(193.53,77.99) v3(193.58,77.25) v3(193.84,72.99) v3(193.85,72.23) v3(193.81,70.67) v3(193.86,71.41) v3(193.86,69.91) v3(193.86,69.15) v3(194.12,78.45) v3(194.34,77.35) v3(194.6,72.99) v3(194.72,78.01) v3(194.7,70.7) v3(194.7,69.91) v3(194.7,69.15) v3(194.77,72.17) v3(194.8,71.45) v3(195.41,72.93) v3(195.53,72.1) v3(195.62,71.35) v3(202.07,67.5) v3(202.07,66.69) v3(202.93,67.47) v3(202.93,66.66) v3(203.77,67.47) v3(203.77,66.66) v3(204.61,67.47) v3(204.61,66.66) v3(210.37,66.33) v3(210.37,65.57) v3(210.37,64.81) v3(211.23,66.31) v3(211.23,65.54) v3(211.23,64.78) v3(212.07,66.31) v3(212.07,65.54) v3(212.07,64.78) v3(212.91,66.31) v3(212.91,65.54) v3(212.91,64.78)
+VH28: length 2.8
  TOP w0.102: v1(196.6,22.57) 197.19,21.98 197.82,21.98 198.18,22.34 198.99,22.34
AC_OFF: length 312.7
  TOP w0.102: v2(13.98,89.07) 14.38,89.47 PR23.2
  TOP w0.254: PR23.2 18.29,89.47 PQ5.2
  IN1 w0.089: v2(225.81,20.97) 222.7,17.85 204.8,17.85 204.68,17.97 204.65,17.97 201.9,20.71 198.41,20.71 197.96,21.16 191.06,21.16 191.06,21.16 190.28,21.16 190.27,21.16 188.43,23 186.65,23 184.01,25.65 184.01,29.88 180.12,33.77 157.26,33.77 154.97,31.48 145.42,31.48 144.2,32.7 139.68,32.7 138.06,34.33 114.18,34.33 112.76,35.75 100.59,35.75 98.71,33.87 94.8,33.87 93.89,34.78 87.41,34.78 85.73,36.46 79.51,36.46 78.85,35.8 76.56,35.8 75.67,36.68 69.13,36.68 67.72,38.09 65.08,38.09 63.43,39.74 62.16,39.74 59.93,41.97 50.75,41.97 49.34,40.55 47.91,40.55 46.13,42.33 37.36,42.33 34.39,45.3 34.39,49.01 32.05,51.34 25.18,51.34 23.99,52.54 20.84,52.54 18.6,54.77 18.6,57.82 16.49,59.94 16.49,67.33 15.67,68.14 15.67,72.13 15.29,72.51 15.29,82.11 14.97,82.43 14.97,83.2 15.5,83.73 15.5,86.32 14,87.82 14,89.05 v2(13.98,89.07)
  BOTTOM w0.102: U23.69 234.63,42.69 234.5,42.56 234.5,36.9 231.83,34.23 231.83,32.45 232.24,32.04 233.73,32.04 234.55,31.22 234.55,29.96 235.37,29.15 235.37,27.03 236.1,26.29 236.1,24.54 236.44,24.2 v1(236.44,23.64) 236.44,23.03 234.91,21.5 233.79,21.5 233.17,20.88 229.76,20.88 229.24,20.36 226.42,20.36 v2(225.81,20.97)
AC_OK: length 84.9
  TOP w0.127: v2(22.44,86.54) 20.91,86.54 20.73,86.36 PQ6.2
  TOP w0.254: PQ16.6 49.83,25.43 49.39,25.87 v2(49.39,26.02)
  IN2 w0.254: v2(22.44,86.54) 19.72,83.82 19.72,74.61 22.33,72 22.33,68.16 28.05,62.44 28.05,60.44 28.55,59.94 28.55,58.67 30.08,57.14 30.08,56.17 v2(30.69,55.56) 32.84,55.56 40.13,48.27 45.08,48.27 47.44,45.91 47.44,39.9 48.75,38.59 48.75,35.98 48.79,35.94 48.79,34.87 49.64,34.02 49.64,26.78 49.39,26.53 v2(49.39,26.02)
  BOTTOM w0.254: v2(30.69,55.56) 30.34,55.56 29.79,56.1 PR180.1
AC_PRESENT: length 143.4
  TOP w0.102: R78.1 175.37,83.92 172.79,83.92 172.14,84.57 171.45,84.57 171.14,84.88 170.65,84.88 170.65,84.87 170.25,84.87 169.6,85.52 169.6,86.29 169.6,86.48 168.83,87.26 168.11,87.26 167.85,87.01 164.16,87.01 163.68,86.52 160.42,86.52 159.68,87.26 158.43,87.26 158.07,86.9 156.26,86.9 155.3,85.94 v2(155.04,85.94)
  IN3 w0.076: v2(155.04,85.94) 155.59,85.94 156.77,84.76 158.32,84.76 158.38,84.7
  IN3 w0.114: v2(228.89,31.41) 228.89,31.18 228.35,30.64 226.93,30.64 226.62,30.33 219.57,30.33 218.57,29.32 217.99,29.32 211.58,29.32 211.52,29.32 210.7,30.15 210.51,30.15 210.13,30.15 209.9,30.15 209.07,30.97 200.08,30.97 200.03,31.02 199.89,31.16 199.76,31.29 199.29,31.76 197.17,31.76 196.77,32.16 195.03,33.9 189.83,33.9 181.82,41.91 179.84,41.91 179.26,41.34 176.33,41.34 173.61,44.06 173.2,44.06 172.42,44.84 168.77,44.84 161.5,52.11 161.5,65.35 161.51,65.37 161.51,73.81 159.16,76.16 159.16,81.39 159.6,81.82 159.6,83.93 158.83,84.7 158.38,84.7
  BOTTOM w0.076: v2(155.04,85.94) 155.1,85.88 U14.AJ8
  BOTTOM w0.102: v2(228.89,31.41) 228.86,31.43 228.15,31.43 227.89,31.17 U23.112
ACAV_IN: length 224.4
  TOP w0.102: v2(202.26,19.51) 202.4,19.37 207.3,19.37 207.81,19.87 207.81,21.58 204.76,24.62 204.76,28.61 204.48,28.89 204.48,31.16 203.7,31.94 201.61,31.94 200.54,33.01 200.54,37.55 195.44,42.66 v1(195.44,43.14) 195.44,46.23 193.81,47.86 v2(193.81,48.83) ; v2(52.76,22.49) 52.74,22.47 PR102.1 ; Q33.2 v2(189.31,19.77)
  TOP w0.254: PR104.2 49.83,21.07 50.15,21.07 50.48,21.4 PQ16.2 50.48,23.28 50.65,23.45 50.95,23.45 51.13,23.28 PQ16.3 52.02,22.49 PR102.1
  IN1 w0.089: v2(202.26,19.51) 202.26,19.78 201.76,20.28 201.02,20.28 198.79,18.05 197.08,18.05 197.03,17.99 190.61,17.99 189.31,19.29 v2(189.31,19.77) 188.63,20.46 186.22,20.46 182.72,23.95 182.72,27.48 183.27,28.03 183.27,30.26 180.04,33.49 157.44,33.49 157.41,33.46 157.39,33.46 155.16,31.23 144.78,31.23 143.66,32.34 139.69,32.34 137.99,34.04 113.71,34.04 112.7,35.05 100.66,35.05 98.92,33.31 94.75,33.31 93.66,34.4 86.42,34.4 81.97,29.96 74.71,29.96 73.8,29.04 61.78,29.04 60.41,27.67 54.21,27.67 53.32,26.78 53.32,23.05 v2(52.76,22.49)
  BOTTOM w0.102: D12.1 194.62,49.64 v2(193.81,48.83)
ACN: length 62.8
  TOP w0.254: v2(40.32,53.57) 40.86,54.11 41.44,54.11 v1(43.76,51.79) 43.76,50.06 51.29,42.53 51.29,37.25 52.05,36.49 52.05,36.05 53.58,34.53 53.58,32.45 54.47,31.57 54.47,25.93 55.48,24.91 55.48,22.82 54.12,21.45 51.96,21.45 50.05,19.54 47.1,19.54 46.59,20.05 46.59,21.55 PC75.1 46.81,23.04 46.81,24.37 46.62,24.56 PC61.1 46.73,25.07 PU3.1
  BOTTOM w0.102: PR183.2P 35.18,55.7 35.37,55.89 38.34,55.89 40.32,53.92 v2(40.32,53.57)
ACP: length 60.3
  TOP w0.254: PU3.2 47.23,25.14 PC61.2 47.4,24.62 47.24,24.46 47.24,22.68 PC76.1 46.97,21.42 46.97,20.21 47.26,19.93 49.89,19.93 51.8,21.83 53.96,21.83 55.1,22.97 55.1,24.75 54.08,25.77 54.08,31.23 53.07,32.24 53.07,34.28 51.54,35.8 51.54,36.49 50.94,37.1 50.94,42.38 43.16,50.15 43.16,51.46 v1(42.11,52.52) 41.09,53.54 v2(41.04,53.54)
  BOTTOM w0.102: v2(41.04,53.54) 38.48,56.09 35.42,56.09 35.18,56.34 PR183.1P
ACZ_SPKR: length 211.4
  TOP w0.102: C354.1 299.44,27.54 299.51,27.47 299.96,27.47 300.39,27.04 v2(300.67,27.04)
  IN3 w0.114: v2(170.67,93.61) 170.77,93.51 171.44,93.51 171.48,93.55 174.13,93.55 174.91,92.77 175.2,92.48 175.2,89.72 175.04,89.56 175.04,82.25 175.33,81.96 175.33,76.15 169.4,70.22 169.4,62.64 171.09,60.95 171.33,60.71 171.33,59.96 169.4,58.03 169.4,53.92 169.77,53.55 176.03,47.29 176.44,47.29 176.44,47.29 178.12,47.29 179.26,46.16 182.74,46.16 188.62,40.27 190.46,40.27 192.07,38.66 194.12,38.66 196.2,36.58 196.2,36.58 197.89,34.89 200.24,34.89 200.59,34.53 209.29,34.53 210.56,33.26 219.26,33.26 219.77,33.77 225.68,33.77 226.19,34.28 230.87,34.28 231.04,34.45 234.81,34.45 235.26,34 240.8,34 243.39,36.59 261.28,36.59 262.12,37.43 265.58,37.43 267.11,35.9 267.98,35.9 268.23,35.65 274.1,35.65 275.51,34.24 277.29,34.24 278.16,33.37 280.99,33.37 283.32,31.04 283.32,30.49 288.55,25.26 294.37,25.26 295.17,26.06 298.28,26.06 298.88,26.66 300.29,26.66 v2(300.67,27.04)
  BOTTOM w0.076: 163.43,93.08 163.07,93.08 162.21,92.22 162.21,92.01 161.85,91.64 160.68,91.64 160.26,91.23 160.02,91.23 159.73,91.52 U14.V2
  BOTTOM w0.102: v2(300.67,27.04) 300.72,27.04 300.92,27.24 300.92,28.03 v1(301.05,28.15) ; 163.43,93.08 164.02,93.08 164.05,93.05 167.57,93.05 167.92,93.41 169.76,93.41 169.96,93.61 v2(170.67,93.61)
ADSP_SIN0: length 1.8
  TOP w0.102: TP70.1 272.35,43.29 271.95,42.9 U7.28
ADSP_SOUT0: length 3.3
  TOP w0.102: TP69.1 272.96,45.58 272.37,44.99 272.37,43.7 271.97,43.3 U7.29
ALERT: length 8.1
  TOP w0.102: v2(188.83,86.83) 188.81,86.8 188.81,85.91 189.26,85.46 189.26,83.76 v1(188.83,83.32) 188.7,83.2 188.7,81.75 188.2,81.24 R98.1
  BOTTOM w0.102: U13.F8 188.44,87.2 188.78,86.85 188.81,86.85 v2(188.83,86.83)
ALW_ON: length 135.1
  TOP w0.102: Q32.2 187.31,19.44 187.61,19.75 v2(188.5,19.75) ; v1(145.41,29.56) 145.65,29.81 v2(145.65,30.26) 145.65,31.11 PQ15.2
  IN1 w0.089: v2(188.5,19.75) 188.04,20.2 186.2,20.2 182.53,23.87 182.53,27.71 183.08,28.25 183.08,30.16 179.97,33.27 157.55,33.27 154.34,30.06 154.34,28.36 153.83,27.85 147.91,27.85 145.65,30.11 v2(145.65,30.26)
  IN3 w0.114: v2(239.12,27.11) 239.12,23.53 238.39,22.8 238.39,18.53 237.8,17.94 190.31,17.94 v2(188.5,19.75)
  BOTTOM w0.102: U23.83 236.69,37.09 236.89,36.89 237.83,36.89 238.21,36.51 239.76,36.51 240.11,36.16 240.11,33.56 239.89,33.33 239.89,31.87 239.25,31.23 239.25,27.24 v2(239.12,27.11)
AMP_BEEP: length 3.9
  TOP w0.102: R379.2 301.33,29.96 v1(301.46,30.09) 301.46,30.54 302.04,31.13 302.04,31.66 302.16,31.78 U10.12
AP_24M: length 165.2
  TOP w0.102: v2(175.65,69.43) 175.19,68.97 161.71,68.97 160.11,67.37 152.03,67.37 149.59,69.81 R117.2 ; U7.7 v2(264.94,41.3)
  IN3 w0.114: v2(250.67,50.75) 249.85,50.75 248.78,49.67 243.67,49.67 241.59,47.59 239.2,47.59 238.08,46.47 229.8,46.47 229.14,45.81 220.1,45.81 219.13,44.84 208.53,44.84 208.18,45.19 202.13,45.19 199.26,48.06 199.26,52.2 193.58,57.87 181.64,57.87 177.61,61.91 177.61,67.47 v2(175.65,69.43)
  BOTTOM w0.102: v2(250.67,50.75) 250.54,50.62 247.72,50.62 245.41,48.31 245.41,47.29 247.89,44.82 251.65,44.82 252.22,45.39 256.33,45.39 v1(256.95,46.01) 257.16,46.21 268.97,46.21 269.22,45.96 269.22,44.9 268.95,44.63 267.76,44.63 264.94,41.8 v2(264.94,41.3)
AP_DIGITAL_CLK: length 44.8
  TOP w0.102: R194.2 297.04,37.45 295.61,38.87 295,38.87 294.79,38.66 293.01,38.66 291.68,37.32 v1(290.89,37.32) 290.89,36.66 290.41,36.18 288.38,36.18 288.22,36.34 288.22,36.68 288.13,36.77 287.78,37.12 284.23,37.12 284.01,36.89 284.01,35.29 283.47,34.76 281.57,34.76 280.56,35.76 278.96,35.76 278.39,36.33 277.71,36.33 277.27,35.9 v2(277.27,35.8) ; U7.4 265.3,42.5 v2(264.27,43.52)
  IN2 w0.114: v2(277.27,35.8) 277.27,36.59 275.7,38.16 275.7,38.47 274.1,40.07 272.88,40.07 271.64,41.31 266.64,41.31 264.43,43.52 v2(264.27,43.52)
AP_DIGITAL_D1: length 37.4
  TOP w0.102: v2(265.06,43.5) 265.66,42.9 U7.3 ; v2(278.17,35.77) 278.39,35.77 278.8,35.37 280.48,35.37 281.36,34.48 283.9,34.48 286.34,36.92 287,36.92 287.32,36.6 287.32,36.43 287.77,35.98 293.61,35.98 294.32,35.27 R215.2
  IN2 w0.114: v2(265.06,43.5) 265.06,43.22 266.74,41.55 271.73,41.55 272.98,40.3 274.2,40.3 275.93,38.56 275.93,38.26 278.17,36.02 v2(278.17,35.77)
AP_I2S_DIN: length 55.3
  TOP w0.102: v2(305.82,27.52) 305.82,27.64 R263.1 ; U7.33 269.84,46.58 269.98,46.72 271.48,46.72 271.58,46.62 273.11,46.62 273.52,46.21 273.52,45.05 273.39,44.92 273.39,44.1 v2(273.29,44)
  IN3 w0.114: v2(305.82,27.52) 306.38,28.07 306.38,28.82 305.71,29.48 305.71,32.85 302.67,35.89 302.67,36.48 298.43,40.72 295.94,40.72 295.49,40.27 293.21,40.27 291.78,38.84 286.26,38.84 283.37,41.72 281.74,41.72 281.49,41.97 280.7,41.97 280.45,41.72 279.46,41.72 279.08,42.1 279.08,43.09 278.62,43.55 275.19,43.55 274.74,44 v2(273.29,44)
  BOTTOM w0.102: v2(305.82,27.52) 305.37,27.98 v1(305.29,27.98)
AP_I2S_DOUT: length 1.9
  TOP w0.102: U7.32 270.24,46.2 R211.1
APWROK: length 108.3
  TOP w0.102: v2(171.56,87.64) 171.94,88.02 173.65,88.02 173.73,88.1 R62.1 173.73,89.12 v1(174.02,89.42)
  IN1 w0.089: v2(171.56,87.64) 171.76,87.84 172.6,87.84 173.77,86.68 173.77,70.9 173.56,70.69 173.56,68.57 174.77,67.36 174.79,67.36 174.79,67.34 174.79,66.22 175.82,65.19 175.82,65.15 186.27,54.7 186.27,51.15 187.21,50.21 187.21,46.62 187.59,46.25 187.59,45.45 193.08,39.95 193.7,39.95 197.6,36.05 197.6,35.9 197.59,34.43 198.2,33.82 199.35,33.82 200.15,34.63 203.74,34.63 207.45,30.91 209.14,30.91 210.28,29.78 218.57,29.78 219.25,30.46 221.4,30.46 221.86,30.91 224.18,30.91 224.7,31.43 v2(224.7,31.69)
  BOTTOM w0.102: v2(224.7,31.69) 224.82,31.81 224.82,33.51 224.37,33.97 222.66,33.97 222.39,33.69 222.39,32.06 222.39,31.94 221.49,31.05 U23.128
APWROK_R: length 18.2
  TOP w0.102: R62.2 172.27,88.51 171.94,88.84 171.94,89.29 172.19,89.54 R60.1 171.53,89.72 171.36,89.55 168.28,89.55 168.17,89.65 v1(167.47,89.65) 167.37,89.65 167.32,89.6 167.06,89.6 166.81,89.34 165.61,89.34 165.49,89.22 163.66,89.22 162.77,90.11 161.38,90.11 160.93,90.56 159.99,90.56 159.59,90.16 v2(157.68,90.16)
  BOTTOM w0.102: U14.AB5 157.51,89.98 v2(157.68,90.16)
AUDIO_I2S_BCLK: length 2.4
  TOP w0.102: U10.16 305.06,30.44 v1(304.48,29.86) 304.4,29.78 R262.2
AUDIO_I2S_DIN: length 52.1
  TOP w0.102: v2(271.2,44.92) 271.14,44.99 R211.2 ; v2(309.61,30.09) 309.06,30.64 U10.24
  IN3 w0.114: v2(309.61,30.09) 309.61,31.1 308.92,31.79 308.36,31.79 307.88,32.27 306.94,32.27 303.28,35.93 303.28,36.99 300.97,39.31 300.97,39.81 299.35,41.44 296.01,41.44 295.36,40.78 293.21,40.78 291.63,39.2 286.43,39.2 283.5,42.13 281.89,42.13 280.7,43.32 279.87,43.32 277.86,45.33 277.1,45.33 276.32,44.55 273.17,44.55 272.86,44.24 271.77,44.24 271.2,44.81 v2(271.2,44.92)
  BOTTOM w0.102: v2(309.61,30.09) 309.63,30.11 v1(309.63,30.8)
AUDIO_I2S_DOUT: length 2.3
  TOP w0.102: R263.2 305.42,29.38 305.77,29.73 305.77,29.83 v1(305.75,29.86) 305.56,30.05 U10.17
AUDIO_I2S_LRCK: length 2.3
  TOP w0.102: U10.18 306.06,30.24 306.27,30.03 306.27,29.33 306.48,29.12 R264.2
AUDIO_PWR_EN: length 9.4
  BOTTOM w0.076: U14.P1 160.27,93.77 160.64,94.14 161.3,94.14 161.47,94.3 161.94,94.3 162.15,94.51
  BOTTOM w0.102: 162.15,94.51 162.39,94.75 163.53,94.75 163.64,94.86 165.96,94.86 R314.2 166.47,95.09 166.66,94.91 167.75,94.91 v1(168.31,95.46)
B_TEMP_MBAT: length 8.4
  TOP w0.102: CN18.3 31.7,10.74 v1(31,11.44)
  BOTTOM w0.254: CN18.3 31.34,10.32 PR205.1 30.62,11.67 30.54,11.6 29.91,11.6 PR204.1 29.91,11.99 PC199.2 30.64,13.13 ESD6.6
BAT_LED_AMBER: length 162.5
  TOP w0.102: LED2.1 163.67,126.12 162.77,126.12 160.56,123.91 157.4,123.91 157.38,123.89 157.34,123.89 152.69,119.24 152.69,115.77 v1(151.55,114.64) 150.88,113.97 150.88,112.78 151.64,112.03 152.81,112.03 153.47,111.37 163.01,111.37 164.81,113.17 169.27,113.17 170.01,112.43 v2(170.59,112.43)
  IN2 w0.114: v2(170.59,112.43) 172.68,112.43 173.39,111.72 173.39,107.68 174.48,106.59 174.48,103.36 177.66,100.19 178.42,100.19 179.99,98.61 179.99,96.15 179.79,95.95 179.79,94.25 180.3,93.74 180.3,92.92 180.75,92.47 180.75,88.98 180.76,88.98 180.76,88.61 180.75,88.53 179.12,86.9 179.12,85.24 179.46,84.9 179.46,82.41 179.12,82.07 179.12,81.59 179.42,81.29 179.42,80.72 179.12,80.43 179.12,78.17 179.86,77.43 179.86,76.75 179.84,76.73 179.84,75.83 183.5,72.17 183.5,60.21 188.88,54.82 188.88,49.57 189.59,48.86 192.9,48.86 194.42,50.38 194.42,51.34 194.17,51.6 v2(194.17,52.89)
  BOTTOM w0.102: U23.30 219.02,43.49 218.6,43.06 218.6,42.02 217.1,40.52 210.12,40.52 208.77,41.87 208.77,43.32 206.76,45.33 201.74,45.33 200.26,46.8 200.26,48.55 199.35,49.47 199.35,51.5 198.15,52.69 196.45,52.69 195.89,53.25 194.52,53.25 v2(194.17,52.89)
BATDIS_ID_DOD: length 4.4
  TOP w0.254: PQ20.4 37.58,23.23 v1(37.14,23.66) 36.8,23.31 PR109.2 36.17,23.94 36.37,24.13 PQ17.3
BATLOW#_R: length 4.2
  TOP w0.102: R2.1 v1(168.13,125.97) 166.48,125.97 LED2.2
BATSHIP: length 218.7
  TOP w0.102: v2(30.23,14.01) 30.22,13.99 30.22,13.85 30.92,13.14 PQ22.2
  IN3 w0.114: v2(206.54,20.36) 205.82,21.07 202.95,21.07 201.53,22.49 201.53,23.13 200.94,23.72 191.74,23.72 189.4,26.05 186.67,26.05 179.15,33.56 157.58,33.56 154.97,30.95 146.55,30.95 145.85,31.65 138.93,31.65 138.84,31.56 129.37,31.56 128.51,32.41 120.23,32.41 119.72,31.91 115.16,31.91 109.61,26.35 105.44,26.35 104.22,25.13 97.26,25.13 96.36,24.22 95.35,24.22 93.38,26.2 91.98,26.2 89.7,23.91 86.19,23.91 85.28,23 76.79,23 76.44,22.64 59.14,22.64 55.31,18.81 49.13,18.81 48.88,19.06 35.16,19.06 30.23,14.13 v2(30.23,14.01)
  BOTTOM w0.102: v2(206.54,20.36) 206.54,20.92 207.32,21.7 209.23,21.7 209.86,22.34 211.74,22.34 211.9,22.19 213.88,22.19 214.82,23.13 214.82,29.04 215.12,29.35 216.6,29.35 217.64,30.39 v1(217.64,30.77) 217.64,31.63 218.05,32.05 218.47,32.05 218.7,32.29 U23.2
BBS: length 23.4
  TOP w0.102: v2(155.73,95.88) 156.31,96.46 157.31,96.46 157.62,96.76 157.62,97.2 158.62,98.21 159.67,98.21 159.83,98.36 159.83,98.8 160.61,99.58 161.83,99.58 v1(162.24,99.99) 162.46,99.99 164.54,102.07 168.67,102.07 169.47,102.07 171.4,104 R24.2 172.59,104.41 173.94,104.41 R25.1
  BOTTOM w0.102: v2(155.73,95.88) 155.56,95.7 U14.L8
BEEP: length 101.8
  TOP w0.102: C345.1 301.35,27.93 v2(301.71,27.57)
  IN3 w0.114: v2(223.25,36.05) 223.6,36.4 228.87,36.4 229.47,35.81 235.51,35.81 235.92,35.39 239.5,35.39 242.45,38.34 256.07,38.34 256.78,37.63 259.32,37.63 260.1,38.42 266.05,38.42 267.56,36.9 268.47,36.9 268.74,36.64 275.34,36.64 276.61,35.37 277.88,35.37 278.14,35.11 280.64,35.11 283.18,32.57 284.84,32.57 285.34,32.07 286.87,32.07 287.31,31.63 287.31,29.11 289.18,27.23 290.05,26.36 293.19,26.36 295.46,28.64 299.09,28.64 299.32,28.41 300.87,28.41 v2(301.71,27.57)
  BOTTOM w0.102: v1(302.45,27.44) 301.84,27.44 v2(301.71,27.57) ; U23.34 221.89,43.91 223.96,41.85 223.96,39.71 222.69,38.44 222.69,36.61 v2(223.25,36.05)
BID0: length 7.4
  BOTTOM w0.102: U23.66 236.42,43.89 236.51,43.98 236.51,44.87 236.69,45.05 237.74,45.05 R443.1 239.2,45.54 240.28,45.54 v1(240.32,45.5) 240.51,45.31 R442.1
BID1: length 10.8
  BOTTOM w0.102: v1(244.81,42.76) 240.64,42.76 240.51,42.89 R447.1 239.86,43.29 239.45,42.89 238.34,42.89 238.23,43 R448.1 238.06,43.29 236.65,41.89 U23.71
BQ24707_ILIM: length 8
  TOP w0.102: v1(52.51,33.67) 52.51,32.68 PR65.1
  TOP w0.254: PU3.10 49.94,29.29 50.48,29.83 51.55,29.83 PR64.1 ; PR64.1 52.32,30.59 53.24,30.59 PR67.1 ; PR64.1 52.19,30.86 52.57,31.24 PC47.1 PR65.1
BREATH_LED: length 146.3
  TOP w0.102: v2(171.16,111.91) 169.51,111.91 169.45,111.95 168.53,112.87 164.8,112.87 163.09,111.16 153.39,111.16 152.73,111.82 151.1,111.82 150.19,112.74 v1(150.19,113.16) 150.19,113.99 152.48,116.28 152.48,119.37 157.67,124.55 Q1.2
  IN2 w0.114: v2(171.16,111.91) 170.62,111.37 170.62,105.47 178.98,97.11 178.98,93.46 180.53,91.91 180.53,88.66 178.75,86.88 178.75,85.23 179.23,84.75 179.23,82.64 178.89,82.31 178.89,81.47 179.09,81.27 179.09,80.81 178.89,80.61 178.89,78.31 178.89,78.06 179.61,77.34 179.61,75.74 181.59,73.76 181.59,69.43 v2(181.49,69.33)
  BOTTOM w0.102: v2(181.49,69.33) 181.69,69.33 183.73,67.3 183.73,65.93 186.17,63.49 187.51,63.49 191.35,59.65 191.35,54.75 193.94,52.16 195.51,52.16 195.66,52.31 197.95,52.31 199.14,51.12 199.14,49.36 199.96,48.55 199.96,46.67 201.58,45.05 206.66,45.05 208.52,43.19 208.52,41.82 210.02,40.32 218.16,40.32 218.93,41.09 U23.24
BREATH_PWRLED#: length 7.4
  TOP w0.102: LED1.1 152.25,126.03 154.29,123.99 v1(155.3,123.99) 156.29,123.99 157.51,125.21 Q1.3
BT_RADIO_DIS#: length 147.1
  TOP w0.102: v1(75.55,30.34) 75.55,29.58 v2(75.47,29.5)
  IN3 w0.076: v2(156.47,93.97) 156.07,94.37 156.02,94.37 156.01,94.38 155.69,94.38 155.58,94.27 154.81,94.27 154.41,93.86
  IN3 w0.114: 154.41,93.86 153.73,93.86 153.68,93.92 149.77,93.92 149.62,93.76 145.7,93.76 145.61,93.67 144.1,93.67 142.76,95.01 137.42,95.01 136.76,94.34 133.45,94.34 130.51,91.4 127.19,91.4 126.02,90.23 122.46,90.23 121.32,89.09 121.32,88.31 120.78,87.77 120.21,87.77 118.98,86.54 118.98,78.35 112.84,72.2 112.84,66.53 112.33,66.03 112.33,63.99 112.84,63.49 112.84,54.91 109.68,51.74 109.68,51.07 105.22,46.61 105.22,37.19 101.27,33.24 96.01,33.24 94.22,35.03 91.01,35.03 90.64,34.66 87.77,34.66 81.68,28.57 78.2,28.57 77.28,29.5 v2(75.47,29.5)
  BOTTOM w0.102: v2(156.47,93.97) 156.21,93.7 U14.R7 ; v2(75.47,29.5) 74.51,29.5 72.75,31.25 72.75,32.63 73.52,33.39 73.52,37.76 72.57,38.7 CN14.54
BT_WAKE#: length 12.1
  TOP w0.102: R123.1 160.76,73.22 160.71,73.27 v1(160.71,74.15) 160.71,78.99 160.18,79.52 160.18,82.61 v2(159.14,83.65)
  BOTTOM w0.102: U14.AM3 158.84,83.95 v2(159.14,83.65)
BUF_PLT_RST#: length 78.7
  TOP w0.102: R135.1 175.77,75.08 176,74.84 v2(176.87,74.84)
  BOTTOM w0.102: v2(176.87,74.84) 176.76,74.84 176.21,74.3 U15.4 175.49,74.39 R114.2 175.49,75.74 175.22,76.01 174.13,76.01 v1(173.62,75.5) 173.08,74.97 173.08,74.18 172.27,73.37 172.27,72.02 172.5,71.79 177.53,71.79 182.89,66.43 182.89,65.58 186.1,62.37 187.44,62.37 190.38,59.43 190.38,54.5 191.83,53.05 191.83,52.28 193.05,51.07 194.06,51.07 194.45,50.68 195.99,50.68 196.17,50.86 198.31,50.86 198.43,50.74 198.43,49.01 199.2,48.25 199.2,46.41 201.27,44.33 206.01,44.33 207.83,42.51 207.83,41.52 209.87,39.48 217.48,39.48 217.72,39.72 218.24,39.72 218.8,40.29 U23.22
BXTALOUT: length 10.6
  BOTTOM w0.102: U13.C10 190.08,84.62 189.7,84.24 189.7,82.07 188.27,80.65 188.27,78.8 188.33,78.75 188.33,78.1 188.1,77.86 187.82,77.86 187.29,77.34 R382.1 186.7,77.52 186.7,77.79 186.47,78.01 v2(185.99,78.01)
CARD_+3.3V_EN: length 4.7
  BOTTOM w0.076: 161.63,85.49 160.52,85.49 160.26,85.23 159.95,85.23 U14.AL2
  BOTTOM w0.102: 161.63,85.49 161.72,85.49 161.76,85.46 163.68,85.46 R354.1
CATERR#: length 12.1
  TOP w0.102: TP44.1 113.01,96.76 113.9,97.65 114.92,97.65 115.88,96.68 116.49,96.68 117.03,96.15 119.9,96.15 v2(120.3,96.56)
  BOTTOM w0.076: v2(120.3,96.56) 120.3,96.63 120.62,96.95 120.98,96.95 121.12,97.1 122.3,97.1 122.49,96.91 122.49,96.42 U14.K61
CBN: length 5.6
  TOP w0.305: U10.35 310.46,36.78 311.51,37.83 312.61,37.83 313.37,38.59 C274.2 v1(314.74,38.59)
CBP: length 2.8
  TOP w0.305: U10.36 310.12,37.28 v1(311.12,38.28) 311.44,38.59 C274.1
CEXT: length 6
  TOP w0.102: v1(246.44,35.37) 246.62,35.19 C532.1
  TOP w0.254: C532.1 248.06,34.63 249,34.63 249.56,35.19 250.1,35.19 250.35,34.94 250.35,34.56 250.79,34.11 U25.2
CFG: length 2.8
  TOP w0.102: U2.23 v2(311.12,86.03)
  BOTTOM w0.102: v1(310.42,86.37) 310.78,86.37 v2(311.12,86.03) 311.12,85.81 R357.2
CFG0: length 11.4
  BOTTOM w0.076: U14.AC60 123.17,88.98 122.69,88.98 122.66,89.02 121.87,89.02 121.7,88.86 120.09,88.86 119.67,88.43 116.55,88.43 116.12,88 R339.1 115.78,88 115.68,87.9
  BOTTOM w0.102: v1(113.04,88.02) 113.39,88.02 113.9,87.51 115.3,87.51 115.68,87.9
CFG0_8330: length 7.5
  TOP w0.102: U25.5 250.31,32.61 v1(249.72,33.21) 249.72,32.75 248.85,31.89 246.09,31.89 R510.1 R507.1
CFG1: length 4.3
  BOTTOM w0.076: U14.AC62 121.93,89.31 121.64,89.02 119.95,89.02 119.9,88.97 v1(119.31,88.97) 118.13,88.97 R334.1
CFG1_8330: length 11.5
  TOP w0.102: U25.40 255.99,36.38 256.32,36.71 256.32,40.32 256.62,40.63 257.67,40.63 v1(257.91,40.38) 258.01,40.28 258.92,40.28 259.52,39.68 R511.1 260.08,38.91 260.08,38.09 260.47,37.7 R508.1
CFG3: length 4.8
  BOTTOM w0.076: TP25.1 119.87,90.03 120.38,89.52 120.76,89.52 121.3,90.06 U14.AA63
  BOTTOM w0.102: R330.1 TP25.1
CFG4: length 13.2
  TOP w0.102: v2(123.17,89.69) 122.6,89.12 117.67,89.12 117.4,89.39 115.85,89.39 115.73,89.27 R61.1 113.5,89.55 113.4,89.55 113.24,89.7 111.94,89.7 v1(111.35,89.11)
  BOTTOM w0.102: U14.AA60 123.47,89.99 v2(123.17,89.69)
CFG5: length 10.1
  BOTTOM w0.076: 120.24,90.37 120.95,90.37 121.1,90.52 121.64,90.52 121.93,90.81 U14.Y62
  BOTTOM w0.102: TP26.1 112.91,89.65 115.04,89.65 115.32,89.93 115.32,90.21 115.66,90.54 120.07,90.54 120.24,90.37
CFG6: length 14.7
  TOP w0.102: TP8.1 109.87,89.9 113.33,89.9 113.48,89.75 113.82,89.75 114.16,90.09 114.16,90.1 114.69,90.64 116.48,90.64 116.76,90.36 121.69,90.36 v2(122.52,91.19)
  BOTTOM w0.076: U14.Y61 122.81,90.89 v2(122.52,91.19)
CFG7: length 9.3
  TOP w0.102: v2(120.58,89.93) 120.25,89.6 115.45,89.6 TP7.1
  BOTTOM w0.076: U14.Y60 123.17,90.48 122.69,90.48 122.66,90.52 121.87,90.52 121.7,90.35 121.29,90.35 120.86,89.93 v2(120.58,89.93)
CFG8: length 8.4
  BOTTOM w0.076: U14.V62 121.71,91.1 121.32,91.1 121.25,91.18 120.62,91.18 120.2,90.77 116.3,90.77 R326.1 115.79,91.18 115.68,91.07
  BOTTOM w0.102: 115.68,91.07 114.84,90.23 v1(114.74,90.23)
