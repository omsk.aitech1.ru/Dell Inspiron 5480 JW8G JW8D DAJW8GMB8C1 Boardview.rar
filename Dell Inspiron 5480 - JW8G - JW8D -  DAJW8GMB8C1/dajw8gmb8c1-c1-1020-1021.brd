# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TESTLOW_2: length 11.1
  TOP w0.102: v2(155.43,84.97) 156.39,84.01 156.39,81.8 156.83,81.37 156.83,79.92 156.29,79.39 156.29,78.17 156.9,77.56 v1(156.9,76.95) 157.56,76.95 157.77,76.74 RP7.3
  BOTTOM w0.076: 155.45,84.97 155.52,84.97 U14.AK8
  BOTTOM w0.102: v2(155.43,84.97) 155.45,84.97
TESTLOW_3: length 9.9
  TOP w0.076: v2(156.83,83.98) 157.22,83.59 157.22,80.14 157.21,80.12
  TOP w0.102: 157.21,80.12 157.21,79.85 157.62,79.44 v1(157.62,78.32) 157.62,77.71 158.42,76.9 RP7.1
  BOTTOM w0.102: v2(156.83,83.98) 156.27,83.98 156.09,84.16 156.09,84.39 U14.AL8
TESTMODE: length 8.1
  BOTTOM w0.102: v1(190.05,108.55) 190.42,108.18 R284.1 190.99,107.99 190.69,107.68 190.69,104.86 190.69,104.86 190.69,104.51 190.44,104.25 189.9,104.25 189.7,104.05 189.7,102.68 189.28,102.26 U13.AD9
THERM_ALERT#: length 2.9
  TOP w0.102: U3.6 114.08,65.95 R139.2 113.78,64.87 113.99,64.67 v1(113.99,64.68)
THERM_STP#: length 103.4
  TOP w0.102: v2(121.32,72.35) 119.46,72.35 117.73,70.62 117.73,69.54 117.65,69.46 Q13.3 ; v2(171.53,58.81) 171.81,58.53 180.34,58.53 181.92,56.96 191.93,56.96 192.36,57.39 192.85,57.39 195.05,55.18 195.05,54.4 192.54,51.89 192.54,51.01 191.37,49.85 190.91,49.85 187.91,46.85 v1(187.49,46.85) R160.1
  BOTTOM w0.102: v2(171.53,58.81) 168.33,55.61 148.88,55.61 137.83,66.66 129.04,66.66 123.07,72.63 121.6,72.63 v2(121.32,72.35)
THERMAL_STP#_CTRL: length 73.3
  TOP w0.102: v2(113.32,69.24) 112.77,68.69 v1(111.87,68.69) 111.74,68.69 111.23,69.21 R132.2
  IN3 w0.076: 155.26,93.73 155.43,93.73 155.58,93.58 155.97,93.58 155.97,93.58 156.64,93.58 156.65,93.59 156.94,93.59 156.95,93.57 157.27,93.57 157.28,93.59 157.57,93.59 157.58,93.57 157.91,93.57 157.93,93.6 159.21,93.6 159.61,94 159.61,94.71 159.96,95.06 v2(160.63,95.06)
  IN3 w0.114: v2(113.32,69.24) 113.42,69.24 113.8,69.62 113.8,72.81 114.54,73.55 119.01,78.01 119.01,78.05 119.21,78.25 119.21,86.45 120.23,87.46 121.42,87.46 121.57,87.62 121.57,88.63 122.2,89.26 124.13,89.26 124.87,90 126.11,90 126.27,90.16 127.21,90.16 128.18,91.12 130.97,91.12 133.16,93.31 136.53,93.31 136.94,93.71 136.94,94.09 137.63,94.78 142.63,94.78 144.07,93.34 145.6,93.34 145.8,93.53 149.72,93.53 149.89,93.71 153.58,93.71 153.64,93.65 154.53,93.65 154.62,93.73 155.26,93.73
  BOTTOM w0.076: U14.L4 158.54,94.88 160.45,94.88 v2(160.63,95.06)
TOUCH_PANEL_INTR#: length 7.5
  BOTTOM w0.076: U14.K2 159.62,96.02 159.92,96.31 160.41,96.31 160.51,96.41 162.05,96.41 162.33,96.69
  BOTTOM w0.102: 162.33,96.69 163.28,97.64 163.28,98.09 163.76,98.56 165.7,98.56 R305.1
TOUCHPANEL_EN: length 18.6
  TOP w0.102: R39.1 171.59,97.9 171.39,98.11 v1(170.77,98.11) 170.11,98.11 169.55,98.67 165.01,98.67 163.33,96.99 163.33,96.79 162.11,95.57 160.41,95.57 159.8,94.96 158.96,94.96 158.83,94.83 158.3,94.83 157.85,94.37 156.8,94.37 156.38,94.79 v2(156.38,94.92)
  BOTTOM w0.102: v2(156.38,94.92) 156.21,94.75 U14.N7
TP_DC_TEST_A4: length 7.2
  BOTTOM w0.102: U14.A4 158.73,102.22 159.27,102.22 159.44,102.4 160.88,102.4 162.26,103.77 162.29,103.77 162.31,103.8 163.13,103.8 TP56.1
TP_DC_TEST_A62: length 6.9
  TOP w0.102: TP41.1 123.02,104.02 122.11,103.11 v2(122.11,102.4)
  BOTTOM w0.305: U14.A62 v2(122.11,102.4)
TP_DC_TEST_AV1: length 5.8
  TOP w0.102: v2(160.85,80.13) 160.92,80.07 160.92,75.73 TP54.1
  BOTTOM w0.076: v2(160.85,80.13) 160.74,80.25 160.43,80.25 160.26,80.42
  BOTTOM w0.381: 160.26,80.42 U14.AV1
TP_DC_TEST_AW1: length 3.6
  TOP w0.102: TP52.1 161.32,76.85 v2(161.32,78.15)
  BOTTOM w0.076: 160.14,79.37 161.32,78.19 v2(161.32,78.15)
  BOTTOM w0.381: 160.14,79.37 U14.AW1
TP_DC_TEST_AW63: length 5.3
  BOTTOM w0.102: 120.79,78.95 120.79,75.32 TP64.1
  BOTTOM w0.381: 120.79,78.95 U14.AW63
TP_DC_TEST_AY60: length 4.9
  BOTTOM w0.102: TP65.1 124.82,76.52 123.39,77.95 U14.AY60
TP_DC_TEST_B2: length 6.1
  BOTTOM w0.102: U14.B2 159.72,101.32 159.72,101.74 159.95,101.97 161.06,101.97 162.43,103.34 164.27,103.34 TP57.1
TP_SMB_RUN_CLK: length 5.5
  TOP w0.102: v2(185.3,28.33) 185.3,28.48 185.38,28.56 185.38,28.93 185.25,29.06 R248.2
  BOTTOM w0.102: v1(184.74,29.17) 184.85,29.06 R478.2 185.3,28.45 v2(185.3,28.33) 185.9,27.73 CN15.6
TP_SMB_RUN_DAT: length 6.6
  TOP w0.102: v2(185.96,28.38) 185.91,28.43 R249.2
  BOTTOM w0.102: v1(187.18,30.87) 187.41,30.64 187.41,29.18 187.29,29.06 R477.2 186.25,28.38 v2(185.96,28.38) 186.9,27.45 CN15.5
TPCLK: length 68.1
  TOP w0.102: L18.1 194.27,27.04 194.28,27.05 R269.1 195.74,27.05 195.87,26.92 195.87,25.79 195.56,25.49 v1(195.56,25.03) 195.56,19.68 195.56,19.51 196.49,18.58 200.33,18.58 200.46,18.7 209.12,18.7 v2(210.14,19.72)
  BOTTOM w0.102: U23.89 236.38,34.69 236.84,34.23 236.84,33.01 237.5,32.35 237.5,32 238.87,30.63 238.87,28.18 236.56,25.87 236.56,24.92 237.22,24.25 237.22,23.24 235.08,21.09 234.28,21.09 233.53,20.35 230.12,20.35 229.49,19.72 v2(210.14,19.72)
TPCLK-1: length 5.9
  TOP w0.102: v1(193.45,25.67) 193.45,26.94 193.35,27.04 L18.2 191.89,27.04 191.88,27.05 C361.2 191.49,27.05 190.99,27.55 v2(190.36,27.55)
  BOTTOM w0.102: CN15.2 189.9,27.17 190.28,27.55 v2(190.36,27.55)
TPDATA: length 68.3
  TOP w0.102: v2(209.46,19.77) 208.59,18.9 200.37,18.9 200.25,18.78 196.58,18.78 195.77,19.59 195.77,22.97 196.07,23.28 v1(196.07,23.74) 196.07,27.06 195.46,27.67 195.46,28.27 R259.1 194.28,28.3 194.27,28.31 L17.1
  BOTTOM w0.102: U23.90 236.42,34.29 236.63,34.07 236.63,32.92 237.3,32.26 237.3,31.91 238.67,30.54 238.67,28.41 236.36,26.1 236.36,24.84 237.02,24.17 237.02,23.32 234.99,21.3 234.09,21.3 233.41,20.62 229.94,20.62 229.36,20.04 210.68,20.04 210.44,20.28 209.96,20.28 v2(209.46,19.77)
TPDATA-1: length 5.8
  TOP w0.102: L17.2 191.89,28.31 191.88,28.3 C344.2 190.02,28.3 189.7,27.98 v2(189.7,27.55)
  BOTTOM w0.102: CN15.3 188.9,27.33 189.11,27.55 v2(189.7,27.55)
TPM_LPC_PD: length 12.9
  TOP w0.102: v2(158.49,86.65) 158.9,87.06 159.6,87.06 160.33,86.32 162.07,86.32 162.68,85.71 163.15,85.71 164.24,86.8 168,86.8 168.26,87.06 168.59,87.06 169.07,86.57 TP50.1
  BOTTOM w0.076: v2(158.49,86.65) 158.19,86.95 U14.AG4
TPSCR_EN: length 73.8
  IN2 w0.114: v2(258.61,28.56) 258.2,28.97 248.89,28.97 247.99,28.07 245.11,28.07 242.61,25.57 240.04,25.57 236.02,21.55 230.46,21.55 230.28,21.74 227.45,21.74 v2(227.04,21.32)
  BOTTOM w0.102: U23.108 229.49,29.13 229.85,28.77 229.85,27.1 229.78,27.03 229.78,24.07 v2(227.04,21.32) ; CN11.20 281,33.14 280.5,33.64 279.46,33.64 278.16,34.94 274.96,34.94 274.33,35.57 271.05,35.57 270.9,35.72 270.32,35.72 269.76,35.17 269.76,32.55 268.84,31.63 266.02,31.63 v1(264.5,30.11) 264.31,29.92 261.21,29.92 259.85,28.56 v2(258.61,28.56)
TRA_V_DAC:
  vias: v1(300.41,52.39) v2(299.7,55.74) v2(299.7,54.85) v2(299.7,48.12) v2(299.7,47.36)
URAT1_CTS: length 16.8
  TOP w0.102: v2(158.49,97.14) 158.49,97.15 158.91,97.57 159.75,97.57 160.23,98.06 160.23,98.63 160.77,99.17 163.03,99.17 164.65,100.8 169.55,100.8 v1(170.85,102.09) 170.85,102.46 171.32,102.93 RP5.4
  BOTTOM w0.076: v2(158.49,97.14) 158.19,96.84 U14.J4
URAT1_RST: length 15.7
  TOP w0.102: RP6.4 171.3,101.28 v1(170.76,100.74) 169.78,99.76 169.37,99.76 168.76,100.37 165.18,100.37 162.68,97.87 161.7,97.87 v2(161.12,97.29)
  BOTTOM w0.076: U14.J3 159.1,96.47 159.61,96.47 159.85,96.71 159.85,96.89 160.02,97.06 160.88,97.06 v2(161.12,97.29)
URAT1_RX: length 16.5
  TOP w0.102: RP6.2 171.36,100.63 170.24,99.5 169.33,99.5 168.67,100.16 165.72,100.16 v1(165.31,99.76) 165.17,99.61 164.71,99.61 162.63,97.53 161.99,97.53 161.32,96.86 159.75,96.86 158.53,95.64 v2(158.49,95.64)
  BOTTOM w0.076: v2(158.49,95.64) 158.19,95.94 U14.K4
URAT1_TX: length 14.9
  TOP w0.102: RP5.2 171.82,101.95 171.48,101.61 170.9,101.61 169.57,100.28 v1(169.52,100.28) 169.18,100.28 168.87,100.6 165.01,100.6 163,98.59 v2(162.09,98.59)
  BOTTOM w0.076: 161.5,98.08 161.46,98.04 160.85,98.04 160.61,97.81 159.78,97.81 U14.G2
  BOTTOM w0.102: 161.5,98.08 161.76,98.08 162.09,98.41 v2(162.09,98.59)
USB2_CAM1_PWR_EN: length 16.9
  TOP w0.102: v2(171.69,83.04) 171.94,82.79 v1(171.94,82.36)
  IN3 w0.114: v2(171.69,83.04) 169.38,83.04 168.55,83.87 163.67,83.87 162.47,85.08 v2(161.3,85.08)
  BOTTOM w0.076: v2(161.3,85.08) 161.3,85.03 160.91,84.64 160.42,84.64 160.26,84.48 159.95,84.48 159.79,84.32 159,84.32 158.96,84.36 158.48,84.36 U14.AM4
  BOTTOM w0.102: R365.1 v2(171.69,83.04)
USB3.0_RD_EN: length 11.3
  BOTTOM w0.076: 161.63,82.88 160.49,82.88 U14.AP1
  BOTTOM w0.102: 161.63,82.88 162.58,82.88 v1(164,84.3) 164.4,84.7 165.31,84.7 165.49,84.87 166.71,84.87 167.34,85.5 167.34,87.21 166.74,87.81 R338.1
USB3.0_RX1+: length 190.4
  TOP w0.114: CN4.6 12.45,56.94 12.56,56.83 12.96,56.83 13.39,57.26 15.35,57.26 15.88,57.8 15.88,58.6 16.46,59.18 16.61,59.18 16.73,59.3 EU3.9 EU3.2 18.24,59.3 18.42,59.12 18.52,59.12 19.29,58.36 19.72,58.36 v1(20.28,58.91) 20.76,58.43 20.94,58.43 22.31,59.8 23.38,59.8 23.55,59.98 v2(23.55,60.11)
  IN1 w0.102: v2(148.45,97.45) 148.45,97.5 148.15,97.79 147.7,97.79 146.53,96.62 145.96,96.62 144.15,94.82 128.36,94.82 127.24,95.93 124.97,95.93 123.74,94.7 120.95,94.7 120.63,95.02 117.56,95.02 117.2,95.38 114.95,95.38 113.42,93.85 113.42,91.39 111.28,89.25 111.28,83.55 110,82.28 110,78.1 111.23,76.87 111.23,74.57 110.09,73.43 110.09,61.1 95.61,46.62 80.5,46.62 79.65,47.47 74,47.47 72.88,46.35 48.92,46.35 46.5,48.77 41.04,48.77 31.12,58.69 29.85,58.69 27.88,60.65 23.37,60.65 23.08,60.36 23.08,60 23.18,59.91 23.35,59.91 v2(23.55,60.11)
  BOTTOM w0.076: v2(148.45,97.45) 148.52,97.52 149.08,97.52 149.16,97.45 149.16,97.36 U14.H20
USB3.0_RX1-: length 190.4
  TOP w0.114: CN4.5 12.45,56.46 12.56,56.57 13.06,56.57 13.5,57.01 15.46,57.01 16.14,57.69 16.14,58.49 16.57,58.93 16.66,58.93 16.78,58.8 EU3.10 EU3.1 18.25,58.8 18.31,58.86 18.42,58.86 19.18,58.1 19.82,58.1 v1(20.28,57.64) 20.81,58.18 21.04,58.18 22.41,59.55 23.43,59.55 v2(23.55,59.42)
  IN1 w0.102: v2(23.55,59.42) 23.55,59.43 23.32,59.67 23.08,59.67 22.84,59.9 22.84,60.46 23.27,60.9 27.98,60.9 29.95,58.93 31.22,58.93 41.14,49.01 46.6,49.01 49.02,46.6 72.78,46.6 73.9,47.71 79.75,47.71 80.6,46.86 95.51,46.86 109.85,61.2 109.85,73.53 110.99,74.67 110.99,76.77 109.76,78 109.76,82.38 111.04,83.65 111.04,89.35 113.18,91.49 113.18,93.95 114.85,95.62 117.3,95.62 117.66,95.26 120.73,95.26 121.05,94.94 123.64,94.94 124.87,96.18 127.34,96.18 128.46,95.06 144.05,95.06 145.86,96.86 146.43,96.86 147.6,98.03 148.4,98.03 v2(148.45,98.08)
  BOTTOM w0.076: v2(148.45,98.08) 148.71,97.82 U14.G20
USB3.0_RX2+: length 204.8
  TOP w0.114: CN6.6 14.08,74.56 14.16,74.48 14.56,74.48 14.87,74.79 14.87,76.04 15.16,76.33 15.31,76.33 v1(15.83,76.85) 15.83,76.62 16.04,76.41 16.24,76.41 16.69,76.87 16.91,76.87 17,76.96 EU1.9 EU1.2 18.54,76.96 18.6,76.9 18.98,76.9 19.72,76.16 20.68,76.16 21.01,75.83 21.01,75.35 v2(21.09,75.27)
  IN1 w0.102: v2(21.09,75.27) 21.09,70.89 23.3,68.68 23.3,64.76 22.96,64.41 22.96,63.07 24.01,62.01 29.78,62.01 42.02,49.77 46.86,49.77 49.3,47.33 72.35,47.33 73.46,48.44 96.03,48.44 108.66,61.06 108.66,82.3 110.31,83.95 110.31,90.25 111.73,91.67 111.73,95.07 113.34,96.68 118.83,96.68 119.39,96.13 121.73,96.13 122.61,97.01 124.21,97.01 124.64,97.44 125.64,97.44 126.18,96.9 128.38,96.9 129.28,96 143.56,96 145.41,97.85 145.41,100.37 146.25,101.21 149.49,101.21 150.24,100.46 150.24,99.36 149.87,99 149.59,99 v2(149.44,98.84)
  BOTTOM w0.076: v2(149.44,98.84) 149.81,98.47 U14.F18
USB3.0_RX2-: length 204.8
  TOP w0.114: CN6.5 13.98,73.3 13.98,74.04 14.17,74.23 14.66,74.23 15.12,74.69 15.12,75.93 15.26,76.07 15.34,76.07 v1(15.83,75.58) 15.83,75.86 16.14,76.16 16.34,76.16 16.8,76.62 16.95,76.62 17.11,76.46 EU1.10 EU1.1 18.54,76.46 18.73,76.64 18.88,76.64 19.61,75.91 20.58,75.91 20.76,75.73 20.76,75.53 20.51,75.27 v2(20.43,75.27)
  IN1 w0.102: v2(20.43,75.27) 20.85,74.85 20.85,70.79 23.06,68.58 23.06,64.86 22.72,64.51 22.72,62.97 23.91,61.77 29.68,61.77 41.92,49.53 46.76,49.53 49.2,47.09 72.45,47.09 73.56,48.2 96.13,48.2 108.9,60.96 108.9,82.2 110.56,83.85 110.56,90.15 111.97,91.57 111.97,94.97 113.44,96.44 118.73,96.44 119.29,95.88 121.83,95.88 122.71,96.77 124.31,96.77 124.74,97.2 125.54,97.2 126.08,96.66 128.28,96.66 129.18,95.76 143.66,95.76 145.65,97.75 145.65,100.27 146.35,100.96 149.39,100.96 150,100.36 150,99.46 149.77,99.24 149.6,99.24 149.44,99.4 v2(149.44,99.5)
  BOTTOM w0.076: v2(149.44,99.5) 149.82,99.12 U14.E18
USB3.0_RX3+: length 247.6
  TOP w0.114: v2(307.33,70.25) 307.15,70.43 307.15,70.7 307.32,70.88 307.75,70.88 308.52,70.12 308.8,70.12 v1(309.3,69.61) 309.81,70.12 310.09,70.12 310.32,69.89 310.89,69.89 311.21,70.21 311.63,70.21 311.75,70.08 EU2.2 EU2.9 313.31,70.08 313.43,70.21 313.87,70.21 315.68,72.02 316.39,72.02 316.8,72.43 317.33,72.43 317.55,72.21 CN5.6
  IN1 w0.102: v2(150.39,98.83) 150.88,98.33 150.88,97.24 151.02,97.1 151.02,96.67 151.47,96.23 155.15,96.23 155.48,96.56 159.9,96.56 160.09,96.75 163.23,96.75 164.32,95.66 169.21,95.66 169.86,95.01 169.86,93.41 170.67,92.59 170.67,91.27 171.94,90 173.07,90 173.69,89.38 173.69,88.41 175.37,86.74 175.37,71.31 174.4,70.34 174.4,68.92 175.12,68.2 175.89,68.2 176.67,67.42 176.67,65.5 187.56,54.6 187.56,51.59 188.55,50.6 188.55,47.14 199.85,35.85 208.95,35.85 210.69,34.11 230.2,34.11 230.81,33.5 234.67,33.5 235.69,34.53 241.21,34.53 242.2,35.52 247.49,35.52 247.94,35.97 251.62,35.97 251.97,35.61 264.87,35.61 267.09,33.39 268.64,33.39 269.74,32.28 277.71,32.28 279.03,33.6 279.03,35.79 281.53,38.29 281.53,44.17 281.87,44.51 281.87,44.91 284.86,47.9 284.86,48.35 285.68,49.17 286.96,49.17 288.4,50.61 290.73,50.61 294.92,54.8 295.64,54.8 296.07,55.23 296.07,57.57 300.91,62.41 301.8,62.41 302.62,63.23 302.62,65.65 303.2,66.22 303.2,67.96 303.62,68.39 303.62,69.71 305.14,71.22 306.74,71.22 307.12,70.84 307.12,70.46 v2(307.33,70.25)
  BOTTOM w0.076: v2(150.39,98.83) 150.75,98.47 U14.F17
USB3.0_RX3-: length 247.6
  TOP w0.114: v2(306.7,70.24) 306.89,70.43 306.89,70.81 307.22,71.13 307.86,71.13 308.62,70.37 308.8,70.37 v1(309.3,70.88) 309.81,70.37 310.19,70.37 310.42,70.14 310.79,70.14 311.11,70.46 311.63,70.46 311.75,70.58 EU2.1 EU2.10 313.31,70.58 313.43,70.46 313.76,70.46 315.58,72.27 316.29,72.27 316.69,72.68 317.36,72.68 317.55,72.88 CN5.5
  IN1 w0.102: v2(150.4,98.18) 150.64,97.94 150.64,97.14 150.78,97 150.78,96.57 151.37,95.99 155.25,95.99 155.58,96.32 160,96.32 160.19,96.51 163.13,96.51 164.22,95.41 169.11,95.41 169.62,94.91 169.62,93.31 170.43,92.49 170.43,91.17 171.84,89.76 172.97,89.76 173.45,89.28 173.45,88.31 175.13,86.64 175.13,71.41 174.16,70.44 174.16,68.82 175.02,67.96 175.79,67.96 176.42,67.32 176.42,65.4 187.32,54.5 187.32,51.49 188.31,50.5 188.31,47.04 199.75,35.61 208.85,35.61 210.59,33.87 230.1,33.87 230.71,33.26 234.77,33.26 235.8,34.29 241.31,34.29 242.3,35.28 247.59,35.28 248.04,35.72 251.52,35.72 251.87,35.37 264.77,35.37 266.99,33.15 268.54,33.15 269.64,32.04 277.81,32.04 279.27,33.5 279.27,35.69 281.77,38.19 281.77,44.07 282.11,44.41 282.11,44.81 285.1,47.8 285.1,48.25 285.78,48.93 287.06,48.93 288.5,50.37 290.83,50.37 295.02,54.56 295.74,54.56 296.31,55.13 296.31,57.47 301.01,62.17 301.9,62.17 302.87,63.13 302.87,65.54 303.44,66.12 303.44,67.86 303.86,68.29 303.86,69.61 305.24,70.98 306.64,70.98 306.88,70.74 306.88,70.42 v2(306.7,70.24)
  BOTTOM w0.076: v2(150.4,98.18) 150.77,97.82 150.8,97.82
  BOTTOM w0.089: 150.8,97.82 U14.G17
USB3.0_TX1+: length 175
  TOP w0.114: v2(23.6,63.77) 23.68,63.77 23.94,63.51 23.94,63 23.73,62.8 v1(23.1,62.8) 23.1,61.97 21.62,60.49 21.47,60.49 21.33,60.63 C205.1
  IN1 w0.102: v2(23.6,63.77) 23.83,63.54 23.83,63.22 24.15,62.9 29.64,62.9 42.28,50.27 47.05,50.27 49.49,47.83 72.17,47.83 73.26,48.92 89.39,48.92 92.46,51.99 98.2,51.99 108.17,61.96 108.17,82.5 109.83,84.15 109.83,90.45 111.25,91.87 111.25,95.31 115.77,99.83 118.27,99.83 119.21,100.77 121.85,100.77 122.73,101.65 125.74,101.65 126.5,102.41 131.86,102.41 135.36,105.91 137.05,105.91 137.36,105.6 137.36,104.7 137.36,104.5 137.8,104.05 138.39,104.05 v2(138.64,103.8)
  BOTTOM w0.076: v2(138.64,103.8) 138.64,103.87 138.84,104.08 139.09,104.08 139.23,103.94 139.23,102.6 139.96,101.87 139.96,100.87 U14.B34
USB3.0_TX1+_C: length 11.6
  TOP w0.114: C205.2 20.29,60.74 19.94,60.74 EC34.2 18.56,60.72 18.35,60.72 18.26,60.8 EU3.5 EU3.6 16.73,60.8 16.61,60.68 16.12,60.68 v1(15.6,61.2) 15.6,60.93 15.35,60.68 15.19,60.68 14.99,60.87 14.99,61.81 14.61,62.19 13.65,62.19 13.09,62.75 12.87,62.75 12.45,63.17 CN4.9
USB3.0_TX1-: length 175
  TOP w0.114: C206.1 21.58,60.23 21.73,60.23 23.39,61.9 v1(24,61.9) 24,62.64 24.19,62.83 24.19,63.69 v2(24.27,63.77)
  IN1 w0.102: v2(138.64,104.43) 138.5,104.29 137.9,104.29 137.6,104.6 137.6,105.7 137.15,106.15 135.26,106.15 131.76,102.65 126.4,102.65 125.64,101.89 122.63,101.89 121.75,101.01 119.11,101.01 118.17,100.07 115.67,100.07 111.01,95.41 111.01,91.97 109.59,90.55 109.59,84.25 107.93,82.6 107.93,62.06 98.1,52.23 92.36,52.23 89.29,49.16 73.16,49.16 72.07,48.07 49.59,48.07 47.15,50.51 42.38,50.51 29.74,63.14 24.25,63.14 24.07,63.32 24.07,63.57 v2(24.27,63.77)
  BOTTOM w0.076: v2(138.64,104.43) 138.84,104.23 139.15,104.23 139.38,104 139.38,102.67 140.11,101.93 140.11,100.91 140.17,100.86 140.17,100.69 U14.C33
USB3.0_TX1-_C: length 11.5
  TOP w0.114: C206.2 20.55,60.14 20.2,60.49 19.63,60.49 EC33.2 18.91,60.46 18.36,60.46 18.2,60.3 EU3.4 EU3.7 16.73,60.3 16.61,60.43 16.1,60.43 v1(15.6,59.93) 15.6,60.15 15.32,60.43 15.08,60.43 14.74,60.77 14.74,61.7 14.51,61.94 13.55,61.94 12.99,62.5 12.61,62.5 12.45,62.34 CN4.8
USB3.0_TX2+: length 184.1
  TOP w0.114: C171.1 22.81,78.46 23.27,78.46 23.55,78.17 23.55,76.62 23.25,76.31 22.94,76.31 v2(22.41,75.78)
  IN1 w0.102: v2(22.41,75.78) 22.84,76.21 23.5,76.21 23.87,75.84 23.87,70.32 39.68,54.51 40.68,54.51 44.18,51 47.34,51 49.76,48.58 71.89,48.58 72.96,49.64 83.59,49.64 88.8,54.85 99.87,54.85 107.45,62.43 107.45,82.8 109.11,84.45 109.11,90.75 110.52,92.17 110.52,96.75 114.34,100.57 117.97,100.57 118.93,101.54 119.87,101.54 121.56,103.22 131.65,103.22 135.06,106.63 137.45,106.63 139.1,104.98 139.1,103.55 139.33,103.31 139.6,103.31 139.8,103.11 v2(139.81,103.11)
  BOTTOM w0.076: v2(139.81,103.11) 139.81,103.19 140.04,103.41 140.21,103.41 140.37,103.25 140.37,102.2 140.57,102 140.57,101.9 U14.A33
USB3.0_TX2+_C: length 12.2
  TOP w0.114: C171.2 21.46,78.79 21.26,78.59 20.76,78.59 EC36.2 20.1,79 20.1,78.52 20,78.42 19.72,78.42 v1(19.29,78.85) 19.29,78.57 19.05,78.33 18.67,78.33 18.54,78.46 EU1.5 EU1.6 16.98,78.46 16.86,78.33 15.95,78.33 15.25,79.03 15.25,80.91 14.79,81.37 14.31,81.37 14.08,81.6 CN6.9
USB3.0_TX2-: length 184.1
  TOP w0.114: C174.1 22.56,78.21 23.16,78.21 23.3,78.07 23.3,76.72 23.14,76.57 22.89,76.57 v2(22.41,77.05)
  IN1 w0.102: v2(139.81,103.77) 139.59,103.55 139.43,103.55 139.34,103.65 139.34,105.08 137.55,106.87 134.96,106.87 131.55,103.47 121.46,103.47 119.77,101.78 118.83,101.78 117.87,100.81 114.24,100.81 110.28,96.85 110.28,92.27 108.87,90.85 108.87,84.55 107.21,82.9 107.21,62.53 99.77,55.09 88.7,55.09 83.49,49.88 72.86,49.88 71.79,48.82 49.87,48.82 47.44,51.24 44.28,51.24 40.78,54.75 39.78,54.75 24.11,70.42 24.11,75.94 23.6,76.45 23.01,76.45 v2(22.41,77.05)
  BOTTOM w0.076: U14.B33 140.41,101.33 140.72,101.64 140.72,102.06 140.52,102.26 140.52,103.31 140.27,103.57 140.02,103.57 v2(139.81,103.77)
USB3.0_TX2-_C: length 12.2
  TOP w0.114: C174.2 21.46,78.18 21.31,78.33 20.79,78.33 EC35.2 19.92,78.08 19.78,78.08 v1(19.29,77.58) 19.29,77.83 19.03,78.08 18.67,78.08 18.54,77.96 EU1.4 EU1.7 16.98,77.96 16.86,78.08 15.84,78.08 14.99,78.93 14.99,80.81 14.69,81.11 14.26,81.11 14.08,80.94 CN6.8
USB3.0_TX3+: length 237.5
  TOP w0.114: C200.1 307.38,66.7 306.68,66.7 306.23,66.25 305.47,66.25 v1(304.88,65.67) 304.33,66.23 303.75,66.23 301.76,64.24 301.76,63.46 v2(301.99,63.23)
  IN1 w0.102: v2(140.44,104.43) 140.65,104.63 140.65,104.91 141.17,105.43 143.58,105.43 144.09,105.94 144.09,107.58 144.54,108.02 146.66,108.02 147.32,107.36 154.25,107.36 155,108.11 157.19,108.11 158.29,107.02 158.29,106.58 160.54,104.33 163.21,104.33 164.55,103 169.9,103 171.36,101.54 174.5,101.54 177.34,98.7 177.34,97.92 178.04,97.22 178.04,95.21 178.99,94.26 178.99,93.47 180.63,91.83 180.63,90.98 181.67,89.94 181.67,86.88 182.72,85.83 182.72,83.08 182.15,82.51 182.15,81.02 181.51,80.38 181.51,70.99 182.41,70.09 182.41,67.84 184.62,65.63 184.62,64.83 188.54,60.91 189.06,60.91 192.27,57.69 192.92,57.69 197.2,53.41 197.2,46.02 201.37,41.86 202.01,41.86 202.44,41.43 209.58,41.43 209.87,41.13 216.61,41.13 217.54,42.06 220.56,42.06 221.28,42.79 223.54,42.79 223.9,42.43 249.77,42.43 250.74,43.41 258.2,43.41 261.4,46.61 277.91,46.61 279.41,48.11 281.67,48.11 282.8,49.24 283.56,49.24 284.94,50.61 286.12,50.61 286.93,51.42 288.9,51.42 299.58,62.1 299.58,62.6 300.99,64.01 301.49,64.01 301.8,63.7 301.8,63.42 v2(301.99,63.23)
  BOTTOM w0.076: U14.C31 141.48,100.71 141.38,100.86 141.34,101.02 141.34,101.2 141.35,101.24 141.4,101.36 141.4,101.46 141.34,101.63 141.34,101.7 140.75,102.28 140.75,104.13 v2(140.44,104.43)
USB3.0_TX3+_C: length 12.8
  TOP w0.114: CN5.9 317.55,66.4 317.42,66.53 317.02,66.53 316.34,67.22 316.07,67.22 314.59,68.7 313.43,68.7 313.31,68.58 EU2.6 EU2.5 311.8,68.58 311.69,68.69 311.56,68.69 311.13,68.26 311.13,67.09 310.68,66.64 310.26,66.64 EC38.2 309.29,66.66 308.91,66.66 C200.2
USB3.0_TX3-: length 237.6
  TOP w0.114: v2(301.35,63.23) 301.51,63.38 301.51,64.35 303.64,66.48 304.43,66.48 v1(304.88,66.94) 305.34,66.49 305.36,66.51 306.13,66.51 306.57,66.95 307.4,66.95 C198.1
  IN1 w0.102: v2(141.11,104.43) 140.89,104.65 140.89,104.81 141.27,105.19 143.68,105.19 144.33,105.84 144.33,107.48 144.64,107.78 146.56,107.78 147.22,107.12 154.35,107.12 155.1,107.87 157.09,107.87 158.05,106.92 158.05,106.48 160.44,104.09 163.11,104.09 164.45,102.75 169.8,102.75 171.26,101.29 174.4,101.29 177.1,98.6 177.1,97.82 177.8,97.12 177.8,95.11 178.75,94.16 178.75,93.37 180.39,91.73 180.39,90.88 181.43,89.84 181.43,86.78 182.48,85.73 182.48,83.18 181.91,82.61 181.91,81.12 181.27,80.48 181.27,70.89 182.16,69.99 182.16,67.74 184.37,65.53 184.37,64.73 188.44,60.67 188.96,60.67 192.17,57.45 192.82,57.45 196.96,53.31 196.96,45.92 201.27,41.62 201.91,41.62 202.34,41.18 209.48,41.18 209.77,40.89 216.71,40.89 217.64,41.82 220.66,41.82 221.38,42.54 223.44,42.54 223.8,42.19 249.87,42.19 250.84,43.17 258.3,43.17 261.5,46.37 278.01,46.37 279.51,47.87 281.77,47.87 282.9,49 283.66,49 285.04,50.37 286.22,50.37 287.03,51.18 289,51.18 299.82,62 299.82,62.5 301.09,63.77 301.39,63.77 301.56,63.6 301.56,63.44 v2(301.35,63.23)
  BOTTOM w0.076: U14.C30 142.09,100.56 141.92,100.73 141.74,100.73 141.53,100.94 141.5,101.04 141.5,101.17 141.53,101.23 141.54,101.24 141.56,101.33 141.56,101.55 141.5,101.68 141.5,101.75 140.9,102.35 140.9,104.23 v2(141.11,104.43)
USB3.0_TX3-_C: length 12.9
  TOP w0.114: C198.2 308.96,66.92 309.29,66.92 EC37.2 310.31,66.89 310.57,66.89 310.88,67.2 310.88,68.37 311.46,68.95 311.64,68.95 311.78,69.08 EU2.4 EU2.7 313.31,69.08 313.43,68.96 314.69,68.96 316.18,67.47 316.44,67.47 317.13,66.79 317.36,66.79 317.55,66.98 CN5.8
USB_BACK_EN: length 233.8
  TOP w0.102: v2(193.71,55.84) 180.53,55.84 179.44,56.93 v1(175.17,56.93) 173.67,56.93 173.41,56.67 170,56.67 162.97,49.64 121.95,49.64 120.89,48.58 120.89,38.64 119.87,37.63 118.43,37.63 117.03,36.23 114.69,36.23 114.28,35.83 107.3,35.83 106.84,35.37 v2(97.14,35.37)
  IN1 w0.089: v2(97.14,35.37) 97.14,36.28 96.04,37.38 82.02,37.38 v2(81.44,37.96)
  IN3 w0.114: v2(26.6,53.68) 36.69,53.68 42.46,47.91 47.16,47.91 48.59,46.48 80.16,46.48 81.24,45.4 81.24,38.16 v2(81.44,37.96)
  BOTTOM w0.102: U23.31 218.97,43.89 218.4,43.32 218.4,42.11 217.01,40.72 210.21,40.72 209,41.93 209,43.45 206.89,45.55 201.94,45.55 200.49,47 200.49,48.65 199.55,49.59 199.55,51.9 198.25,53.2 196.65,53.2 195.94,53.91 194.98,53.91 193.61,55.28 193.61,55.73 v2(193.71,55.84) ; U18.5 26.44,53.85 v2(26.6,53.68)
USB_BIAS: length 13.5
  TOP w0.127: v2(154.08,85.28) 153.86,85.05 152.76,85.05 152.46,84.75 152.46,79.64 151.11,78.29 151.11,76.53 151.02,76.43 R105.1 150.6,75.94 150.38,75.72 v1(150.38,75.3)
  BOTTOM w0.305: U14.AJ10 154.49,85.61 154.16,85.28 v2(154.08,85.28) 154.01,85.28 153.68,85.61 U14.AJ11
USB_CHG_DET#: length 258.9
  TOP w0.102: v2(208.8,19.75) 209.48,20.43 209.48,22.47 209.33,22.62 208.21,22.62 206.38,24.45 206.38,28.26 206.82,28.69 206.82,29.52 205.88,30.46 205.88,31.71 205.69,31.89 205.69,33.51 206.19,34.01 v1(206.42,34.01) 206.84,34.43 206.84,35.57 209.25,37.98 D4.3
  IN1 w0.089: v2(20,54.09) 21.36,52.73 24.06,52.73 25.25,51.55 32.11,51.55 34.58,49.08 34.58,45.38 37.4,42.56 46.26,42.56 48.07,40.75 49.18,40.75 50.59,42.16 60.01,42.16 62.16,40 62.17,40 62.25,39.93 63.51,39.93 65.02,38.42 67.95,38.42 69.3,37.07 75.62,37.07 76.67,36.03 78.69,36.03 79.54,36.88 93.07,36.88 95.18,34.76 97.52,34.76 99.22,36.46 114.54,36.46 116.09,34.91 138.39,34.91 139.94,33.36 144.47,33.36 145.84,31.99 154.66,31.99 156.98,34.3 180.35,34.3 184.56,30.09 184.56,27.85 186.88,25.54 190.03,25.54 192.46,23.1 198.46,23.1 199.52,22.04 201.63,22.04 201.82,22.23 203.31,22.23 204.76,20.78 208.53,20.78 208.8,20.51 v2(208.8,19.75)
  IN2 w0.114: v2(20,54.09) 20.56,54.65 20.56,62.75 18.86,64.45 18.86,65.49 16.51,67.84 16.51,70.81 14.94,72.38 13.5,72.38 12.87,73 CN6.10
USB_CHG_DET#_EC: length 36.4
  TOP w0.102: v2(234.09,42.86) v1(233.08,42.86) 230.82,42.86 229.85,41.9 222.84,41.9 221.45,40.5 218.3,40.5 217.66,41.13 211.56,41.13 211.36,41.34 211.36,41.95 211.16,42.15 210.7,42.15 210.45,41.9 210.45,41.11 211.34,40.22 212.68,40.22 213.44,39.46 R175.1 212.62,36.77 212.07,37.32 D4.2
  BOTTOM w0.102: v2(234.09,42.86) 234.72,43.49 U23.67
USB_LEFT_EN: length 249.4
  IN1 w0.089: v2(307.45,65.7) 307.37,65.77 306.74,65.77 306.14,65.17 306.14,63.49 302.63,59.99 302.06,59.99 299.08,57.01 299.08,56.97 298.98,56.87 298.98,51.05 294.85,46.93 294.85,45.99 294.47,45.6 291.93,45.6 291.66,45.34 288.13,45.34 287.61,44.82 287.61,44.26 284.79,41.44 284.79,38.47 285.89,37.37 286.49,37.37 287.16,36.71 287.16,35.67 287.79,35.04 287.79,34.37 287.07,33.66 285.91,33.66 284.91,32.66 284.91,29.44 283.19,27.72 264.55,27.72 264.07,27.24 260.31,27.24 260.16,27.09 253.78,27.09 252.89,27.98 245.42,27.98 v2(244.58,28.82)
  IN3 w0.114: v2(168.38,86.6) 168.38,85.51 169.88,84.01 172,84.01 172.57,83.44 172.57,82.15 172.33,81.91 172.33,78.4 171.01,77.08 170.26,77.08 168.13,74.94 168.13,72.66 166.25,70.78 166.25,67.75 163.67,65.18 163.67,54.23 173.39,44.51 173.8,44.51 176.37,41.95 178.98,41.95 179.41,42.38 182,42.38 190.02,34.36 195.22,34.36 197.36,32.22 199.48,32.22 200.22,31.48 206.95,31.48 207.61,32.14 208.55,32.14 210.09,30.61 210.32,30.61 210.94,30.61 211.77,29.78 218.38,29.78 219.42,30.82 221.5,30.82 221.5,30.82 222,30.82 226.3,30.82 226.65,31.18 227.87,31.18 228.15,31.46 228.15,31.51 228.15,31.84 228.39,32.07 229.34,32.07 229.6,31.81 229.6,31.62 229.6,31.56 229.8,31.36 236.09,31.36 236.35,31.1 236.35,30.62 237.49,29.48 243.92,29.48 v2(244.58,28.82)
  BOTTOM w0.076: U14.AT3 158.99,81.74 159.24,81.49 159.61,81.49 159.81,81.69 159.81,81.88 160.01,82.07 160.33,82.07 160.58,82.32 161.29,82.32 161.48,82.13 161.63,82.13
  BOTTOM w0.102: 161.63,82.13 161.67,82.13 161.73,82.07 162.97,82.07 165.06,84.16 165.59,84.16 165.77,84.34 167.85,84.34 168.29,84.78 168.29,86.5 v2(168.38,86.6) 168.79,86.6 168.88,86.7 R344.1 ; v1(303.23,67.83) 303.23,67.5 303.86,66.87 U16.4 306.6,66.87 307.32,66.15 307.32,65.82 v2(307.45,65.7)
USB_MCARD1_DET#: length 15.7
  TOP w0.102: v2(161.02,92.24) 161.48,92.7 162.66,92.7 164.64,94.68 165.03,94.68 165.26,94.91 167.65,94.91 168.03,95.29 v1(169.48,95.29) 170.49,95.29 171.18,94.6 171.59,94.6 171.71,94.73 R48.1
  BOTTOM w0.076: U14.U4 158.57,91.85 158.96,91.85 159,91.81 160.33,91.81 160.73,92.21 160.99,92.21 v2(161.02,92.24)
USB_OC0#: length 263.1
  TOP w0.102: R88.1 172.07,81.39 171.46,82 171.46,82.7 171.28,82.88 171.28,82.97 168.92,85.33 168.47,85.33 167.86,85.94 167.08,85.94 166.71,85.57 164.3,85.57 163.84,85.1 162.43,85.1 161.82,85.71 160.97,85.71 160.66,85.41 v2(160.66,85.07)
  IN1 w0.089: v2(308.08,65.67) 307.7,65.29 306.85,65.29 306.33,64.77 306.33,63.44 306.33,63.43 306.33,63.42 302.71,59.8 302.14,59.8 299.27,56.93 299.27,50.94 296.25,47.92 296.25,44.97 295.38,44.11 287.84,44.11 285.02,41.29 285.02,38.62 286.04,37.6 286.72,37.6 287.38,36.94 287.38,35.85 287.99,35.24 287.99,34.31 287.15,33.47 286.01,33.47 285.14,32.6 285.14,29.4 283.26,27.52 264.68,27.52 264.17,27.01 260.38,27.01 260.26,26.88 253.55,26.88 252.7,27.74 245.03,27.74 v2(243.95,28.82)
  IN3 w0.114: v2(243.95,28.82) 243.62,29.15 237.5,29.15 236.12,30.52 236.12,30.95 235.94,31.13 230.05,31.13 230.05,31.13 229.86,31.13 229.86,31.13 229.7,31.13 229.37,31.46 229.37,31.72 229.24,31.84 228.61,31.84 228.38,31.61 228.38,31.23 228.07,30.92 226.86,30.92 226.49,30.55 219.48,30.55 218.48,29.55 218.08,29.55 211.67,29.55 211.62,29.55 210.79,30.38 210.61,30.38 210.42,30.38 210.42,30.38 210.23,30.38 210.23,30.38 209.99,30.38 208.46,31.91 207.7,31.91 207.04,31.25 200.12,31.25 199.99,31.39 199.39,31.99 197.27,31.99 197,32.26 195.13,34.13 189.93,34.13 181.92,42.14 179.49,42.14 179.02,41.67 176.32,41.67 173.71,44.28 173.3,44.28 172.18,45.4 168.61,45.4 162.49,51.52 162.49,67.47 167.83,72.81 167.83,76.01 170.65,78.83 170.65,81.18 172.11,82.64 172.11,83.25 171.81,83.55 169.43,83.55 168.79,84.19 163.84,84.19 162.49,85.53 161.13,85.53 v2(160.66,85.07)
  BOTTOM w0.076: U14.AL3 159.1,84.48 159.61,84.48 159.85,84.72 159.85,84.9 160.02,85.07 v2(160.66,85.07)
  BOTTOM w0.102: v1(311.89,68.11) 310.66,66.87 U16.5 309.06,66.87 308.08,65.9 v2(308.08,65.67)
USB_OC1#: length 218.2
  IN1 w0.089: v2(111.59,48.97) 108.37,45.75 102.24,45.75 97.11,40.63 82.08,40.63 80.22,38.77 77,38.77 76.44,38.21 69.1,38.21 68.56,38.75 64.96,38.75 63.58,40.12 62.32,40.12 62.25,40.19 62.24,40.19 60.09,42.35 50.47,42.35 49.08,40.96 48.19,40.96 46.34,42.81 37.41,42.81 34.77,45.45 34.77,49.16 32.18,51.75 25.31,51.75 24.14,52.92 22.03,52.92 v2(20.91,54.04)
  IN3 w0.076: v2(160.74,81.74) 160.74,81.85 160.03,82.56 160.03,84.14 159.75,84.42 159.75,85.38 159.34,85.79 157.36,85.79 157.23,85.91 156.27,85.91 155.76,86.42 155.48,86.42 154.9,87.01
  IN3 w0.114: v2(19.69,64.78) 21.32,63.16 21.32,61.72 22.32,60.72 23.76,60.72 24.42,60.06 v2(24.42,58.69) 24.42,57.67 20.91,54.16 v2(20.91,54.04) ; 154.9,87.01 154.4,87.51 152.41,87.51 152.03,87.89 149.09,87.89 148.8,88.18 147.51,88.18 146.93,88.76 143.94,88.76 143.24,89.46 133.1,89.46 130.7,87.06 130.6,87.06 129.89,86.35 127.59,86.35 125.84,84.6 125.84,84.15 125.31,83.63 123.71,83.63 121.88,81.8 121.88,79.03 121.5,78.65 121.5,78 121.5,77.59 121.5,77.28 116.28,72.06 116.28,67.51 115.32,66.56 115.32,62.1 115.51,61.92 115.51,53.08 115.32,52.89 115.32,52.51 111.78,48.97 v2(111.59,48.97)
  BOTTOM w0.076: U14.AT1 v2(160.74,81.74) 161.63,81.74
  BOTTOM w0.102: v2(19.69,64.78) 19.07,64.16 U17.5 ; 161.63,81.74 162.93,81.74 165.13,83.93 165.71,83.93 165.86,84.09 167.88,84.09 168.49,84.7 168.49,85.14 168.88,85.53 R350.1 ; U18.13 24.94,58.47 24.72,58.69 v2(24.42,58.69)
USB_OC2#: length 6
  BOTTOM w0.076: 161.63,87.67 161.55,87.67 161.06,87.17 161.06,86.82 160.87,86.63 160.45,86.63 160.35,86.73 159.95,86.73 159.94,86.72 159.94,86.72 U14.AH2
  BOTTOM w0.102: 161.63,87.67 161.83,87.67 163.56,89.39 R332.1
USB_RIGHT_EN: length 214.6
  IN1 w0.089: v2(82.69,37.98) 82.96,37.71 106.38,37.71 v2(107.68,39)
  IN3 w0.076: 154.73,86.87 155.35,86.26 155.69,86.26 156.2,85.75 157.17,85.75 157.29,85.63 157.34,85.57 159.28,85.57 159.55,85.3 159.55,84.29 159.82,84.02 159.82,81.65
  IN3 w0.114: v2(19.07,57.31) 19.07,54.25 19.72,53.61 23.81,53.61 24.8,54.6 36.56,54.6 42.05,49.11 47.1,49.11 49.08,47.13 80.88,47.13 82.08,45.93 82.08,38.92 82.69,38.31 v2(82.69,37.98) ; 159.82,81.65 159.6,81.43 159.6,79.16 159.98,78.78 159.98,78.75 v2(160.08,78.65) ; v2(107.68,39) 108.57,39.89 108.57,43.9 110.78,46.11 110.78,47.34 115.74,52.3 115.74,62.93 116.51,63.7 116.51,64.23 116.51,65.93 116.51,66.12 116.51,70.03 120.57,74.09 120.57,75.16 123.27,77.86 123.27,78.77 126.07,81.56 126.07,84.51 126.87,85.3 129.17,85.3 130.7,86.83 130.79,86.83 132.49,88.53 146.85,88.53 147.42,87.96 148.71,87.96 149,87.67 151.89,87.67 152.31,87.26 154.35,87.26 154.73,86.87
  BOTTOM w0.076: 162.22,78.14 161.84,77.76 160.99,77.76 160.23,78.52 160.21,78.52 v2(160.08,78.65) 159.39,78.65 159.21,78.84 159.21,79.58 159.15,79.63 159.15,80.1
  BOTTOM w0.102: v2(19.07,57.31) U17.4 ; 162.22,78.14 162.32,78.24 163.58,78.24 164.51,77.32 164.51,77.32 165.39,76.44 v1(166.81,76.44) 167.89,76.44 R388.1
  BOTTOM w0.305: 159.15,80.1 U14.AV3
USBP0+: length 182
  IN1 w0.076: v2(155.43,84.34) 155.43,84.34 155.43,84.18 155.57,84.03 155.72,84.03 155.86,84.17 155.86,85.15 155.63,85.38 154.82,85.38 154.49,85.71 154.49,86.18 154.57,86.26 154.57,86.44 154.53,86.49 154.53,86.5
  IN1 w0.102: 154.53,86.5 154.53,86.78 154.19,87.12 152.71,87.12 151.94,87.9 149.16,87.9 148.74,88.31 147.84,88.31 146.73,89.42 130.87,89.42 130.13,88.68 125.22,88.68 125.08,88.82 122.25,88.82 119.44,86.02 119.44,78.78 114.75,74.09 114.75,64.84 114.4,64.49 114.4,59.03 112.25,56.88 112.25,56.16 108.54,52.45 103.56,52.45 94.15,43.04 81.35,43.04 80.16,41.84 64.86,41.84 61.79,44.91 48.31,44.91 45.98,47.24 40.38,47.24 32.86,54.76 27.75,54.76 27.38,55.13 27.38,56.96 26.71,57.63 24.64,57.63 24.18,57.16 24.18,55.74 23.75,55.32 23.34,55.32 23.05,55.03 v2(23.05,54.96)
  BOTTOM w0.114: v2(155.43,84.34) 155.78,83.99 U14.AM8 ; v2(23.05,54.96) 23.05,55.05 22.79,55.31 22.61,55.31 22.39,55.54 22.18,55.54 21.98,55.34 EL8.4
USBP0+_C: length 11.7
  IN1 w0.102: CN4.3 14.2,58.7 14.94,59.45 15.14,59.45 15.26,59.32 15.26,58.61 15.59,58.28 16.52,58.28 17.33,57.47 17.33,57.31 17.23,57.21 v2(16.94,57.21)
  BOTTOM w0.114: EL8.3 20.24,55.49 19.92,55.49 19.74,55.31 19.74,55.05 19.29,54.6 18.42,54.6 18.09,54.93 18.09,55.15 17.86,55.38 17.13,55.38 16.94,55.57 ESD3.1 v2(16.94,57.21)
USBP0-: length 182.1
  IN1 w0.076: v2(155.44,83.66) 155.64,83.86 155.76,83.86 156.02,84.11 156.02,85.22 155.7,85.53 154.88,85.53 154.64,85.77 154.64,86.12 154.73,86.2 154.73,86.45 154.77,86.49 154.77,86.5
  IN1 w0.102: v2(23.05,55.63) 23.12,55.56 23.65,55.56 23.94,55.84 23.94,57.26 24.54,57.87 26.81,57.87 27.62,57.06 27.62,55.23 27.85,55 32.96,55 40.48,47.48 46.08,47.48 48.41,45.15 61.89,45.15 64.96,42.09 80.05,42.09 81.25,43.28 94.05,43.28 103.46,52.69 108.44,52.69 112.01,56.26 112.01,56.98 114.16,59.13 114.16,64.59 114.51,64.95 114.51,74.19 119.2,78.88 119.2,86.12 122.15,89.06 125.18,89.06 125.32,88.92 130.03,88.92 130.77,89.66 146.83,89.66 147.94,88.56 148.84,88.56 149.26,88.14 152.04,88.14 152.81,87.36 154.29,87.36 154.77,86.88 154.77,86.5
  BOTTOM w0.114: EL8.1 22.06,55.89 22.16,55.79 22.49,55.79 22.72,55.56 22.98,55.56 v2(23.05,55.63) ; U14.AN8 v2(155.44,83.66)
USBP0-_C: length 11.7
  IN1 w0.102: v2(18.19,57.47) 17.67,57.47 16.62,58.52 15.69,58.52 15.5,58.71 15.5,59.42 14.22,60.7 CN4.2
  BOTTOM w0.114: EL8.2 20.24,55.74 19.82,55.74 19.49,55.41 19.49,55.16 19.18,54.85 18.53,54.85 18.35,55.03 18.35,55.21 18.49,55.35 18.64,55.35 18.84,55.55 ESD3.3 18.84,56.82 v2(18.19,57.47)
USBP0_BUS_SW_CB0: length 266.5
  TOP w0.102: v2(82.06,37.99) 82.06,38.34 v1(81.78,38.62)
  IN1 w0.089: v2(82.06,37.99) 82.5,38.43 83.21,38.43 83.65,37.98 105.65,37.98 107.08,39.42 108.66,39.42 111.06,37.02 114.44,37.02 116.26,35.19 138.59,35.19 140.17,33.62 144.56,33.62 145.96,32.22 154.54,32.22 156.87,34.56 180.5,34.56 184.79,30.26 184.79,28 187,25.79 190.15,25.79 192.59,23.35 198.66,23.35 199.79,22.23 201.55,22.23 201.74,22.42 203.39,22.42 204.84,20.97 209,20.97 209.79,20.18 214.26,20.18 v2(214.71,20.64)
  IN3 w0.114: v2(82.06,37.99) 81.67,38.38 81.67,45.63 80.5,46.8 48.73,46.8 47.07,48.45 42.38,48.45 36.56,54.27 26.55,54.27 v2(25.97,53.68)
  BOTTOM w0.102: v2(25.97,53.68) 25.94,53.71 U18.6 ; v2(214.71,20.64) 223.27,20.64 223.58,20.33 224.95,20.33 225.28,20.66 225.28,21.12 225.59,21.42 226.22,21.42 227.08,20.56 229.14,20.56 229.71,21.13 232.81,21.13 233.38,21.7 234.72,21.7 235.9,22.88 235.9,26.21 235.16,26.95 235.16,28.82 234.35,29.63 234.35,31.13 233.65,31.84 231.98,31.84 230.78,33.04 230.78,35.51 232.57,37.3 232.57,37.91 232.34,38.14 231.1,38.14 230.95,38.29 230.95,39.84 230.42,40.37 230.42,41.88 230.07,42.23 230.07,44.3 230.69,44.92 U23.56
USBP1+: length 175.1
  IN1 w0.076: 155.66,86.5 155.66,86.48 155.7,86.43 155.7,86.14 156.24,85.6 156.24,82.4 156.41,82.23 156.54,82.23 156.6,82.23 v2(156.8,82.04)
  IN1 w0.102: 155.66,86.5 155.66,86.51 154.28,87.9 152.97,87.9 152.15,88.71 152.15,89.15 151.89,89.42 151.89,89.83 151.6,90.12 150.84,90.12 149.92,91.03 148.85,91.03 148.37,91.51 146.26,91.51 145,90.26 129.85,90.26 129.56,89.97 123.96,89.97 123.68,90.24 121.95,90.24 118.68,86.97 118.68,79.07 114.03,74.42 114.03,65.15 113.51,64.62 113.51,60.43 110.85,57.77 110.85,55.87 110.33,55.35 105.43,55.35 95.82,45.73 80.36,45.73 79.45,46.65 74.2,46.65 73.18,45.63 48.61,45.63 46.2,48.04 40.62,48.04 32.45,56.21 28.55,56.21 28.3,55.97 v2(28.3,55.8)
  BOTTOM w0.114: U18.3 27.7,55.97 27.87,56.15 28.08,56.15 28.3,55.92 v2(28.3,55.8) ; v2(156.8,82.04) 156.47,81.71 U14.AT7
USBP1+_C: length 21.2
  IN3 w0.102: v2(18.4,69.46) 18.25,69.46 17.59,68.79 17.59,68.41 17.36,68.19 16.44,68.19 15.71,68.92 15.71,75.45 14.66,76.49 13.85,76.49 13.32,77.02 13.04,77.02 12.78,76.77 CN6.3
  BOTTOM w0.114: EL7.2 20.81,67.05 20.81,67.55 20.43,67.93 19.68,67.93 18.79,67.04 18.14,67.04 17.99,67.19 17.99,67.52 18.14,67.68 18.63,67.68 18.84,67.89 ESD2.3 18.84,69.01 v2(18.4,69.46)
USBP1+_R: length 16.3
  IN1 w0.102: v2(21.65,58.18) 21.76,58.29 21.76,58.69 21.26,59.19 21.26,63.02 20.77,63.5 20.77,65.21 21.35,65.78 22.13,65.78 22.33,65.99 v2(22.33,66.25)
  BOTTOM w0.114: U18.10 23.52,55.97 23.38,56.12 22.66,56.12 21.88,56.91 21.88,57.95 v2(21.65,58.18) ; EL7.1 20.84,65.53 20.84,65.16 20.91,65.09 21.17,65.09 21.95,65.87 22.21,65.87 22.33,66 v2(22.33,66.25)
USBP1-: length 175
  IN1 w0.076: v2(156.8,82.69) 156.8,82.58 156.6,82.38 156.47,82.38 156.4,82.46 156.4,85.66 155.86,86.2 155.86,86.43 155.9,86.48 155.9,86.5
  IN1 w0.102: 155.9,86.5 155.9,86.61 154.38,88.14 153.07,88.14 152.4,88.81 152.4,89.25 152.13,89.52 152.13,89.93 151.7,90.36 150.94,90.36 150.02,91.27 148.95,91.27 148.47,91.76 146.16,91.76 144.9,90.5 129.75,90.5 129.46,90.21 124.06,90.21 123.78,90.49 121.85,90.49 118.44,87.07 118.44,79.17 113.79,74.52 113.79,65.25 113.27,64.72 113.27,60.53 110.61,57.87 110.61,55.97 110.23,55.59 105.33,55.59 95.72,45.97 80.46,45.97 79.55,46.89 74.1,46.89 73.08,45.87 48.71,45.87 46.3,48.28 40.72,48.28 32.55,56.45 28.45,56.45 v2(28.3,56.6)
  BOTTOM w0.114: v2(28.3,56.6) 28.11,56.4 27.87,56.4 27.8,56.47 U18.2 ; U14.AR7 156.53,82.36 156.8,82.63 v2(156.8,82.69)
USBP1-_C: length 21.3
  IN3 w0.102: v2(16.94,69.46) 17.38,69.01 17.38,68.5 17.27,68.39 16.53,68.39 15.91,69.01 15.91,75.53 14.75,76.69 13.94,76.69 12.78,77.85 CN6.2
  BOTTOM w0.114: EL7.3 20.56,67.05 20.56,67.44 20.32,67.68 19.78,67.68 18.89,66.79 18.04,66.79 17.74,67.09 17.74,67.42 17.48,67.68 17.18,67.68 16.94,67.92 ESD2.1 v2(16.94,69.46)
USBP1-_R: length 16.3
  IN1 w0.102: v2(22.33,64.98) 22.33,65.34 22.13,65.54 21.45,65.54 21.01,65.11 21.01,63.6 21.5,63.12 21.5,59.3 22,58.79 22,58.51 v2(22.33,58.18)
  BOTTOM w0.114: v2(22.33,58.18) 22.13,57.97 22.13,57.01 22.77,56.37 23.4,56.37 23.5,56.47 U18.11 ; EL7.4 20.58,65.48 20.58,65.06 20.81,64.83 21.27,64.83 22.06,65.62 22.21,65.62 22.33,65.49 v2(22.33,64.98)
USBP2+: length 224
  IN1 w0.076: v2(155.43,82.99) 155.68,82.74 155.86,82.74 156.07,82.54 156.07,82.07 156.49,81.64 157.97,81.64
  IN1 w0.102: 157.97,81.64 158.06,81.64 160.85,78.85 160.85,76.99 161.1,76.74 161.1,74.88 162.45,73.52 162.45,70.99 180.04,53.4 180.04,49.59 181.66,47.98 181.66,43.66 181.96,43.36 181.96,42.28 192.88,31.35 192.88,29.51 194.52,27.88 199.71,27.88 200.39,27.2 201.94,27.2 202.94,26.2 206.31,26.2 206.75,25.75 207.55,25.75 208.17,25.13 225.28,25.13 226.06,25.91 226.06,27.31 226.5,27.75 231.17,27.75 232.46,29.03 234.07,29.03 234.53,28.57 239.02,28.57 240.61,30.16 251.9,30.16 252.4,29.66 258.21,29.66 258.95,30.4 263.8,30.4 265.35,28.85 282.66,28.85 283.31,29.5 283.31,30.95 283.85,31.49 283.85,35.42 283.31,35.96 283.31,37.16 283.31,37.16 283.31,37.21 283.31,43.86 286.29,46.84 287.73,46.84 288.31,46.25 290.54,46.25 294.97,50.68 295.81,50.68 297.52,52.4 297.52,56.93 301.42,60.84 302.28,60.84 305.29,63.84 305.29,65.52 305.32,65.54 305.32,66.38 304.68,67.02 304.68,67.67 304.34,68 304.34,68.81 304.63,69.1 305.01,69.1 305.19,69.28 v2(305.19,69.61)
  BOTTOM w0.114: U14.AP8 155.74,82.69 v2(155.43,82.99) ; v2(305.19,69.61) 305.19,69.33 305.42,69.1 305.88,69.1 306,69.22 EL6.4
USBP2+_C: length 13.4
  BOTTOM w0.114: EL6.3 308.03,69.22 308.18,69.07 308.42,69.07 309.26,68.24 309.94,68.24 310.09,68.39 310.09,69.03 309.68,69.44 ESD1.3 309.68,70.28 310.47,71.08 312.81,71.08 v1(313.27,71.54) 313.75,71.06 314.1,71.06 315.32,69.84 315.83,69.84 316.05,70.05 CN5.3
USBP2-: length 224.1
  IN1 w0.076: v2(155.44,82.36) 155.67,82.59 155.8,82.59 155.91,82.47 155.91,82 156.43,81.49 157.88,81.49 157.97,81.39
  IN1 w0.102: 157.97,81.39 160.61,78.75 160.61,76.89 160.85,76.64 160.85,74.78 162.21,73.42 162.21,70.89 179.8,53.3 179.8,49.49 181.42,47.88 181.42,43.56 181.72,43.26 181.72,42.18 192.64,31.25 192.64,29.41 194.42,27.63 199.61,27.63 200.29,26.95 201.84,26.95 202.84,25.96 206.21,25.96 206.65,25.51 207.45,25.51 208.07,24.89 225.38,24.89 226.3,25.81 226.3,27.21 226.6,27.51 231.27,27.51 232.56,28.79 233.97,28.79 234.42,28.33 239.12,28.33 240.71,29.92 251.8,29.92 252.3,29.42 258.31,29.42 259.05,30.16 263.7,30.16 265.25,28.61 282.76,28.61 283.55,29.4 283.55,30.85 284.09,31.39 284.09,35.52 283.55,36.06 283.55,43.76 286.39,46.6 287.63,46.6 288.21,46.01 290.64,46.01 295.07,50.44 295.91,50.44 297.76,52.3 297.76,56.83 301.52,60.6 302.38,60.6 305.53,63.74 305.53,65.42 305.56,65.44 305.56,65.64 305.56,66.48 304.92,67.12 304.92,67.77 304.59,68.1 304.59,68.71 304.73,68.86 305,68.86 305.19,68.67 v2(305.19,68.34)
  BOTTOM w0.114: v2(155.44,82.36) 155.77,82.04 U14.AR8 ; v2(305.19,68.34) 305.19,68.64 305.39,68.85 305.82,68.85 306,68.67 EL6.1
USBP2-_C: length 13.4
  BOTTOM w0.114: CN5.2 316.05,69.34 315.81,69.58 315.22,69.58 314,70.8 313.8,70.8 v1(313.27,70.27) 312.71,70.83 311.34,70.83 311.13,70.62 311.13,70.29 311.57,69.85 ESD1.1 311.57,69.44 311.13,69 310.52,69 310.35,68.82 310.35,68.28 310.04,67.98 309.15,67.98 308.31,68.82 308.16,68.82 308.01,68.67 EL6.2
USBP3+: length 129.3
  IN1 w0.076: v2(154.9,81.39) 155.15,81.65 155.49,81.65 155.98,81.16 156.69,81.16 157.07,80.78 157.07,80.26 157.15,80.19
  IN1 w0.102: 157.15,80.19 159.18,78.15 159.18,75.18 161.43,72.93 161.43,70.64 179.07,53 179.07,46.99 180.54,45.52 180.54,42.29 191.92,30.91 191.92,29.11 194.12,26.91 198.84,26.91 199.7,26.05 201.18,26.05 202.09,25.13 204.44,25.13 205.42,24.15 225.81,24.15 226.64,24.98 235.07,24.98 236.48,26.39 242.54,26.39 243.06,26.91 243.06,27.16 243.19,27.29 v2(243.59,27.29)
  BOTTOM w0.114: U14.AT10 154.55,81.71 154.87,81.39 v2(154.9,81.39) ; v2(243.59,27.29) 243.37,27.29 243.16,27.49 243.16,30.73 243.34,30.91 243.5,30.91 R475.1
USBP3+_R_FT: length 15.1
  BOTTOM w0.114: CN8.2 252.76,38.63 252.65,38.52 252.5,38.52 252.39,38.4 252.39,37.84 251.01,36.46 248.93,36.46 246.77,34.3 246.77,33.59 246.46,33.28 246.46,32.86 246.62,32.7 246.62,32.12 v1(247.05,31.69) 246.77,31.69 246.57,31.48 246.57,31.13 246.26,30.82 245.08,30.82 R475.2
USBP3-: length 129.3
  IN1 w0.076: v2(154.9,82.03) 155.13,81.8 155.56,81.8 156.04,81.32 156.75,81.32 157.22,80.85 157.22,80.45 157.22,80.45 157.32,80.36
  IN1 w0.102: v2(242.32,27.29) 242.76,27.29 242.82,27.23 242.82,27.01 242.44,26.63 236.38,26.63 234.97,25.22 226.54,25.22 225.71,24.4 205.52,24.4 204.54,25.37 202.19,25.37 201.28,26.29 199.8,26.29 198.94,27.15 194.22,27.15 192.16,29.21 192.16,31.01 180.78,42.39 180.78,45.62 179.31,47.09 179.31,53.1 161.67,70.74 161.67,73.03 159.42,75.28 159.42,78.25 157.32,80.36
  BOTTOM w0.114: U14.AR10 154.56,82.36 v2(154.9,82.03) ; R472.1 243.5,31.16 243.23,31.16 242.91,30.84 242.91,27.49 242.71,27.29 v2(242.32,27.29)
USBP3-_R_FT: length 15.1
  BOTTOM w0.114: CN8.3 251.76,38.63 251.87,38.52 252.02,38.52 252.13,38.4 252.13,37.94 250.91,36.71 248.82,36.71 246.52,34.41 246.52,33.7 246.2,33.38 246.2,32.75 246.36,32.6 246.36,32.27 246.2,32.11 v1(245.78,31.69) 246.13,31.69 246.31,31.51 246.31,31.23 246.16,31.08 244.92,31.08 244.72,31.27 R472.2
USBP4+: length 226.5
  TOP w0.114: v2(17.25,105.35) 17.25,105.22 17.59,104.89 18.32,104.89 18.72,105.29 L5.3
  IN1 w0.076: v2(151.55,85.03) 151.34,84.82 151.11,84.82 149.79,86.14 149.07,86.14 148.51,86.7 147.51,86.7 147.3,86.91 147.3,86.97 147.29,86.98
  IN1 w0.102: 147.29,86.98 146.54,87.73 134.72,87.73 132.16,85.18 126.68,85.18 125.47,83.97 123.57,83.97 121.14,81.55 121.14,78.4 116.24,73.49 116.24,68.22 116.89,67.58 116.89,63.81 115.82,62.75 115.82,58.29 113.79,56.26 113.79,55.37 109.46,51.04 106.66,51.04 103.51,47.89 100.85,47.89 94.75,41.79 82.05,41.79 80.32,40.07 64.88,40.07 63.98,40.96 62.68,40.96 60.45,43.19 60.25,43.19 50.69,43.19 50.22,43.66 47.67,43.66 45.6,45.73 40.14,45.73 32.99,52.88 29.87,52.88 29.55,53.2 25.07,53.2 24.5,53.77 22.46,53.77 19.78,56.45 19.78,57.86 17.33,60.31 17.33,67.68 16.52,68.49 16.52,72.48 16.14,72.86 16.14,74.31 16.91,75.08 16.91,86.16 15.93,87.13 15.93,101.57 18.09,103.73 18.09,104.51 17.76,104.84 17.43,104.84 17.25,105.02 v2(17.25,105.35)
  BOTTOM w0.114: U14.AL15 151.94,84.64 v2(151.55,85.03)
USBP4+_CN: length 5
  TOP w0.114: L5.4 21.12,105.29 21.45,104.96 21.75,104.96 v2(22.21,105.42)
  BOTTOM w0.114: v2(22.21,105.42) 22.21,105.07 22.36,104.91 22.8,104.91 23.38,104.33 23.71,104.33 23.83,104.45 CN1.5
USBP4-: length 226.5
  TOP w0.114: L5.2 18.47,104.49 18.32,104.63 17.51,104.63 17.25,104.38 v2(17.25,104.08)
  IN1 w0.076: 147.12,86.81 147.13,86.8 147.19,86.8 147.44,86.55 148.45,86.55 149,85.99 149.73,85.99 151.05,84.67 151.25,84.67 v2(151.52,84.39)
  IN1 w0.102: v2(17.25,104.08) 17.25,104.42 17.43,104.6 17.66,104.6 17.85,104.41 17.85,103.83 15.69,101.67 15.69,87.03 16.67,86.06 16.67,75.18 15.9,74.41 15.9,72.76 16.28,72.38 16.28,68.39 17.09,67.58 17.09,60.21 19.54,57.76 19.54,56.35 22.36,53.53 24.4,53.53 24.97,52.96 25.17,52.96 29.45,52.96 29.77,52.64 32.89,52.64 40.04,45.49 45.5,45.49 47.57,43.42 50.12,43.42 50.59,42.95 60.35,42.95 62.57,40.72 63.88,40.72 64.78,39.83 80.42,39.83 82.15,41.55 94.85,41.55 100.95,47.65 103.61,47.65 106.76,50.8 109.56,50.8 114.03,55.27 114.03,56.16 116.06,58.19 116.06,62.65 117.13,63.71 117.13,67.68 116.48,68.32 116.48,73.39 121.38,78.3 121.38,81.45 123.67,83.73 125.57,83.73 126.78,84.94 132.26,84.94 134.82,87.49 146.44,87.49 147.12,86.81
  BOTTOM w0.114: v2(151.52,84.39) 151.93,83.99 U14.AM15
USBP4-_CN: length 5
  TOP w0.114: v2(22.21,104.15) 21.65,104.71 21.34,104.71 21.12,104.49 L5.1
  BOTTOM w0.114: v2(22.21,104.15) 22.21,104.51 22.36,104.66 22.69,104.66 23.3,104.05 23.76,104.05 23.86,103.95 CN1.6
USBP5+: length 177.5
  IN1 w0.076: v2(152.97,83.98) 152.76,84.19 152.58,84.19 152.36,84.41 152.36,85.14 152.62,85.41 153.34,85.41 154.36,84.38 154.36,80.62 154.68,80.3 156.24,80.3 156.71,79.84 156.77,79.84 156.78,79.82
  IN1 w0.102: v2(279.71,25.6) 280.12,25.6 280.21,25.51 280.21,24.65 280.07,24.51 267.27,24.51 265.41,26.36 260.74,26.36 260.6,26.22 253.22,26.22 252.31,27.13 244.4,27.13 243.02,25.75 240.81,25.75 237.45,22.39 236.74,22.39 236.38,22.74 236.38,23.92 236,24.31 233.69,24.31 233.25,23.86 226.26,23.86 225.6,23.2 220.86,23.2 220.51,23.56 204.92,23.56 204.24,24.24 202.07,24.24 200.85,25.46 194.81,25.46 190.43,29.84 190.43,30.85 187.55,33.73 187.55,33.98 184.07,37.46 181.97,37.46 180.18,39.25 180.18,39.44 179.23,40.39 179.23,43.88 178.52,44.59 178.52,52.82 160.57,70.76 160.57,72.7 158.48,74.8 158.48,77.43 157.87,78.04 157.87,78.74 156.78,79.82
  BOTTOM w0.102: v2(152.97,83.98) 152.65,83.66 U14.AN13
  BOTTOM w0.114: L32.2 279.74,26.76 280.2,26.31 280.2,26.09 v2(279.71,25.6)
USBP5+_TOUCH: length 4
  BOTTOM w0.114: L32.1 279.74,29.3 280.04,29.6 280.04,29.91 279.5,30.45 279.5,31.73 279.61,31.84 279.61,31.91 279.5,32.03 CN11.17
USBP5-: length 177.5
  IN1 w0.076: 156.61,79.65 156.6,79.67 156.6,79.73 156.18,80.15 154.62,80.15 154.21,80.55 154.21,84.31 153.27,85.25 152.69,85.25 152.51,85.08 152.51,84.47 152.64,84.34 152.79,84.34 152.97,84.52 v2(152.97,84.64)
  IN1 w0.102: 156.61,79.65 157.63,78.64 157.63,77.94 158.24,77.33 158.24,74.7 160.33,72.6 160.33,70.66 178.28,52.72 178.28,44.49 178.99,43.78 178.99,40.29 179.94,39.34 179.94,39.15 181.87,37.22 183.97,37.22 187.31,33.88 187.31,33.63 190.19,30.75 190.19,29.74 194.71,25.22 200.75,25.22 201.97,24 204.14,24 204.82,23.32 220.41,23.32 220.76,22.96 225.7,22.96 226.36,23.62 233.35,23.62 233.79,24.07 235.9,24.07 236.14,23.82 236.14,22.64 236.64,22.15 237.55,22.15 240.91,25.51 243.12,25.51 244.5,26.89 252.21,26.89 253.12,25.98 260.7,25.98 260.84,26.12 265.31,26.12 267.17,24.27 280.17,24.27 280.45,24.55 280.45,25.49 280.56,25.6 v2(280.98,25.6)
  BOTTOM w0.102: v2(152.97,84.64) 152.74,84.64 152.57,84.47 U14.AM13
  BOTTOM w0.114: v2(280.98,25.6) 280.45,26.13 280.45,26.43 280.55,26.52 L32.3
USBP5-_TOUCH: length 4
  BOTTOM w0.114: L32.4 280.55,29.37 280.3,29.62 280.3,30.01 279.75,30.56 279.75,31.6 279.87,31.71 279.87,31.91 280,32.05 CN11.18
USBP6+: length 125.8
  IN3 w0.102: v2(153.53,83.64) 153.8,83.37 153.97,83.37 154.16,83.17 154.16,81.19 153.7,80.73 152.76,80.73 152.26,81.24 152.26,84.94 151.71,85.48 151.29,85.48 150.99,85.18 150.49,85.18 149.85,85.81 149.07,85.81 148.41,86.47 146.9,86.47 146.26,87.11 134.31,87.11 131.79,84.59 130.86,84.59 129.46,83.19 129.31,83.04 128.79,83.04 128.51,82.76 128.51,80.63 126.04,78.17 126.04,76.36 122.36,72.67 122.36,70.06 117.55,65.26 117.55,63.22 116.78,62.46 116.78,51.17 114.62,49.01 113.98,49.01 111.83,46.86 111.83,46.55 111.83,46.55 111.83,44.57 109.79,42.53 109.79,37.83 101.86,29.91 91.22,29.91 89.9,28.59 88.34,28.59 87.61,27.87 87.61,26.9 87.02,26.3 84.26,26.3 83.47,25.51 82.22,25.51 81.61,26.12 81.03,26.12 v2(80.79,25.88)
  BOTTOM w0.114: U14.AN11 153.83,83.34 v2(153.53,83.64) ; CN14.3 80.22,25.95 80.34,26.08 80.59,26.08 v2(80.79,25.88)
USBP6-: length 125.8
  IN3 w0.102: v2(80.79,26.7) 80.7,26.62 80.7,26.45 80.83,26.33 81.69,26.33 82.3,25.72 83.39,25.72 84.18,26.5 86.93,26.5 87.41,26.98 87.41,27.95 88.25,28.79 89.82,28.79 91.13,30.11 101.78,30.11 109.59,37.92 109.59,42.62 111.62,44.65 111.62,46.46 111.62,46.94 113.89,49.21 114.54,49.21 116.58,51.26 116.58,62.54 117.35,63.31 117.35,65.34 122.16,70.15 122.16,72.76 125.84,76.44 125.84,78.25 128.3,80.72 128.3,82.85 128.7,83.25 129.23,83.25 129.37,83.39 130.77,84.79 131.71,84.79 134.23,87.31 134.61,87.31 134.78,87.31 134.78,87.31 146.35,87.31 146.98,86.68 148.5,86.68 149.16,86.02 149.98,86.02 150.61,85.38 150.9,85.38 151.21,85.69 151.8,85.69 152.46,85.03 152.46,81.32 152.85,80.94 153.62,80.94 153.98,81.3 153.98,83.1 153.89,83.19 153.71,83.19 v2(153.51,82.99)
  BOTTOM w0.114: v2(153.51,82.99) 153.59,83.07 153.75,83.07 153.92,82.9 U14.AP11 ; CN14.5 80.22,26.45 80.34,26.33 80.5,26.33 80.79,26.62 v2(80.79,26.7)
