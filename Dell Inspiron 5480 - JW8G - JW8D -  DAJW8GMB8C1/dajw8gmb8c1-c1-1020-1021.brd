# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RUN_ENABLE_3: length 110.5
  TOP w0.203: PU6.12 203.33,23.73
  TOP w0.254: 203.33,23.73 204.25,24.65 204.25,28.51 204.05,28.71 204.05,30.65 203.19,31.51 201.41,31.51 200.11,32.81 200.11,37.37 194.65,42.84 v1(194.65,44.28) 194.65,45.53 193.15,47.03 193.15,49.9 v2(193.84,50.58) ; PR15.2 179.93,117.6 v2(179.84,117.51)
  IN2 w0.254: v2(193.84,50.58) 193.84,50.85 185.33,59.36 185.33,68.41 184.81,68.93 184.81,71.81 180.53,76.09 180.53,77.75 179.79,78.49 179.79,79.92 180.25,80.38 180.25,82.89 180.7,83.35 180.7,86.34 181.75,87.38 181.75,87.43 181.75,87.43 181.75,88.64 181.51,88.88 181.51,92.84 182.51,93.84 182.51,95.24 181.97,95.77 181.97,98.21 179.89,100.29 179.89,113.22 178.6,114.51 178.6,116.27 v2(179.84,117.51)
RUN_ON: length 324
  TOP w0.102: v2(89.06,35.34) v1(88.02,35.34) ; v2(108.64,54.77) 109.72,53.7 PR41.1 ; v2(207.25,20.33) 206.48,19.57 203.61,19.57 203.33,19.86 PU6.4 203.33,20.79 203.26,20.86 203.03,20.86 202.93,20.76 PU6.3 202.93,19.75 202.88,19.7 202.65,19.7 202.53,19.82 PU6.2
  IN1 w0.089: v2(105.27,105.88) 105.66,105.48 107.01,105.48 110.52,109 110.52,110.17 112.94,112.58 117.61,112.58 117.89,112.3 120.18,112.3 121.04,113.17 122.89,113.17 123.31,113.59 125.04,113.59 125.28,113.35 127.29,113.35 127.54,113.6 138.39,113.6 139.48,114.69 148.27,114.69 157.85,124.27 v2(162.34,124.27) ; v2(89.06,35.34) 89.64,35.93 93.48,35.93 95,34.4 98,34.4 99.68,36.08 114.49,36.08 115.93,34.63 138.18,34.63 139.76,33.06 144.38,33.06 145.68,31.76 154.85,31.76 157.13,34.05 180.25,34.05 184.31,29.98 184.31,27.77 187.05,25.03 187.74,25.03 190.67,22.1 198.35,22.1 198.8,21.65 201.68,21.65 202.29,21.65 205.04,18.91 206.84,18.91 207.22,19.29 207.22,20.31 v2(207.25,20.33)
  IN3 w0.114: v2(108.64,54.77) 108.51,54.77 97.6,43.86 97.6,42.38 94.78,39.56 93.28,39.56 v2(89.06,35.34)
  BOTTOM w0.102: v2(105.27,105.88) 105.27,105.43 105.5,105.19 107.12,105.19 108.19,104.13 108.19,101.94 105.57,99.33 105.57,94.6 105.11,94.14 105.11,89.5 104.38,88.76 104.38,83.43 103.92,82.97 103.92,78.43 104.45,77.89 104.45,76.1 113.39,67.17 113.39,62.43 108.64,57.69 v2(108.64,54.77) ; U23.123 223.49,29.22 223.53,29.19 223.53,28.92 223.76,28.69 223.76,27.21 223.63,27.09 223.63,25.39 222.75,24.51 222.75,22.83 221.57,21.65 211.46,21.65 211.11,21.3 208.04,21.3 207.27,20.53 207.27,20.36 v2(207.25,20.33) ; PR129.2 162.47,124.4 v2(162.34,124.27)
SATA_IREF: length 9.5
  BOTTOM w0.102: v1(157.29,108.06) 157.54,107.81 157.54,106.24 R288.1
  BOTTOM w0.305: U14.A12 152.97,101.8 152.97,102.81 153.18,103.03 153.18,103.27 154.03,104.13 155.94,104.13 156.68,104.86 156.68,105.38 R288.1
SATA_R_LED1: length 3.5
  TOP w0.102: R3.1 179.28,125.39 v1(178.82,124.93) 177.75,126 LED3.2
SATA_RCOMP: length 7.5
  BOTTOM w0.241: U14.C12 153.05,100.56 153.05,101.23 153.4,101.58 153.4,102.05 153.33,102.13 153.33,102.57 153.76,103 153.76,103.03 154.22,103.49 156.17,103.49
  BOTTOM w0.305: 156.17,103.49 157.33,104.65 R294.1
SATA_RXN1: length 181.1
  TOP w0.114: C364.1 271.89,27.05 271.89,28.94 273.54,30.59 273.78,30.59 274.41,31.23 274.41,32.34 274.33,32.42 274.33,33.34 274.05,33.62 v2(273.64,33.62)
  IN1 w0.102: v2(155.13,96.86) 155.32,97.05 155.96,97.05 156.56,97.65 156.56,98.37 156.88,98.69 157.35,98.69 158.34,97.7 163.43,97.7 164.32,96.81 171.87,96.81 172.64,96.05 172.64,95.34 172.64,93.92 171.99,93.27 171.99,92.1 173.36,90.73 174.46,90.73 175.05,90.13 175.05,88.31 176.17,87.2 176.17,72.68 176.81,72.04 176.81,68.21 177.72,67.3 177.72,65.33 188.46,54.58 188.46,53.68 189.16,52.98 189.16,49.07 190.88,47.36 190.88,47.14 191.41,46.61 191.41,45.15 200.01,36.55 209.19,36.55 209.43,36.31 219.95,36.31 220.19,36.55 228.53,36.55 229.94,35.14 240.79,35.14 241.8,36.16 246.7,36.16 247.35,36.8 251.83,36.8 252.41,36.22 260.59,36.22 261.2,36.83 261.76,36.83 262.36,36.22 265.6,36.22 266,35.83 267.74,35.83 268.65,34.92 268.65,34.24 269.98,32.9 272.09,32.9 272.54,33.35 272.54,33.93 272.72,34.11 274,34.11 274.16,33.95 274.16,33.72 274.06,33.62 v2(273.64,33.62)
  BOTTOM w0.076: U14.J8 155.29,96.86 v2(155.13,96.86)
SATA_RXN1_C: length 4.4
  TOP w0.114: C364.2 271.89,25.5 271.89,24.88 272.27,24.5 272.27,24.23 v1(271.75,23.71) 272.32,23.14 272.32,22.9 271.99,22.57 CN17.5
SATA_RXP1: length 181.1
  TOP w0.114: v2(274.91,33.62) 274.58,33.29 274.58,32.53 274.67,32.44 274.67,31.12 273.88,30.34 273.65,30.34 272.14,28.84 272.14,27.05 C365.1
  IN1 w0.102: v2(155.13,97.5) 155.33,97.29 155.86,97.29 156.32,97.75 156.32,98.47 156.78,98.93 157.45,98.93 158.44,97.94 163.53,97.94 164.42,97.05 171.97,97.05 172.88,96.15 172.88,95.24 172.88,93.82 172.23,93.17 172.23,92.2 173.46,90.97 174.56,90.97 175.29,90.23 175.29,88.41 176.41,87.3 176.41,72.78 177.05,72.14 177.05,68.31 177.96,67.4 177.96,65.43 188.7,54.68 188.7,53.78 189.4,53.08 189.4,49.17 191.12,47.46 191.12,47.24 191.65,46.71 191.65,45.25 200.11,36.79 209.29,36.79 209.53,36.55 219.85,36.55 220.09,36.79 228.63,36.79 230.04,35.38 240.69,35.38 241.7,36.4 246.6,36.4 247.25,37.04 251.93,37.04 252.51,36.46 260.49,36.46 261.09,37.07 261.86,37.07 262.47,36.46 265.7,36.46 266.1,36.07 267.84,36.07 268.89,35.02 268.89,34.34 270.09,33.15 271.99,33.15 272.3,33.45 272.3,34.03 272.62,34.35 274.1,34.35 274.4,34.05 274.4,33.72 274.5,33.62 v2(274.91,33.62)
  BOTTOM w0.076: v2(155.13,97.5) 155.45,97.17 U14.H8
SATA_RXP1_C: length 4.4
  TOP w0.114: C365.2 272.39,25.89 272.14,25.64 272.14,24.98 272.52,24.6 272.52,24.2 v1(273.02,23.71) 272.58,23.27 272.58,22.9 272.91,22.57 CN17.6
SATA_TXN1: length 186
  TOP w0.114: C363.1 268.71,27.05 268.71,27.67 271.62,30.58 271.62,31.66 272.55,32.59 272.55,33.82 272.63,33.9 272.63,34.73 272.96,35.06 v2(273.31,35.06)
  IN1 w0.102: v2(152.18,103.34) 152.18,103.08 152.29,102.97 152.5,102.97 153.64,101.83 157.99,101.83 159.78,100.03 162.48,100.03 164.24,98.27 168.94,98.27 169.44,97.78 172.27,97.78 174.01,96.04 174.01,92.89 175.36,91.54 175.36,91.2 176.46,90.1 176.46,88.4 177.14,87.73 177.14,77.43 177.67,76.9 177.67,73.75 177.78,73.64 177.78,68.62 178.68,67.72 178.68,65.75 189.63,54.8 189.63,54.13 192.53,51.23 192.53,47.79 193.37,46.95 193.37,44.82 200.56,37.63 211.45,37.63 211.77,37.31 219.15,37.31 219.49,37.65 221.23,37.65 221.75,38.17 228.38,38.17 229.61,36.94 240.28,36.94 241.97,38.63 251.36,38.63 252.69,37.3 260.3,37.3 261.45,38.45 265.33,38.45 266.89,36.89 272.02,36.89 272.8,36.11 272.8,35.58 v2(273.31,35.06)
  BOTTOM w0.076: U14.A17 150.32,101.61 150.1,101.61 150,101.71 150,102.03 150.72,102.75 151.77,102.75 151.93,102.91 151.93,103.08 v2(152.18,103.34)
SATA_TXN1_C: length 4.3
  TOP w0.114: C363.2 268.71,25.5 268.71,24.22 v1(269.22,23.71) 268.71,23.2 268.71,22.72 268.86,22.57 CN17.3
SATA_TXP1: length 186
  TOP w0.114: C362.1 268.46,27.05 268.46,27.78 271.37,30.68 271.37,31.77 272.3,32.69 272.3,33.92 272.37,34 272.37,34.73 v2(272.04,35.06)
  IN1 w0.102: v2(151.54,103.34) 152.15,102.73 152.4,102.73 153.54,101.59 157.89,101.59 159.68,99.79 162.38,99.79 164.14,98.03 168.84,98.03 169.34,97.53 172.17,97.53 173.77,95.94 173.77,92.79 175.12,91.44 175.12,91.1 176.22,90 176.22,88.3 176.89,87.63 176.89,77.33 177.43,76.8 177.43,73.65 177.54,73.54 177.54,68.52 178.44,67.62 178.44,65.65 189.39,54.7 189.39,54.03 192.29,51.13 192.29,47.69 193.12,46.85 193.12,44.72 200.46,37.39 211.35,37.39 211.67,37.07 219.25,37.07 219.59,37.41 221.33,37.41 221.85,37.93 228.28,37.93 229.51,36.7 240.38,36.7 242.07,38.39 251.26,38.39 252.59,37.06 260.4,37.06 261.55,38.21 265.23,38.21 266.79,36.65 271.92,36.65 272.56,36.01 272.56,35.58 v2(272.04,35.06)
  BOTTOM w0.076: v2(151.54,103.34) 151.77,103.11 151.77,102.97 151.71,102.91 150.66,102.91 149.84,102.09 149.84,101.65 150.1,101.4 U14.B17
SATA_TXP1_C: length 4.3
  TOP w0.114: CN17.2 268.31,22.57 268.46,22.72 268.46,23.2 v1(267.95,23.71) 268.46,24.22 268.46,25.5 C362.2
SD_CD#: length 44.5
  TOP w0.102: v2(54.72,36.46) 54.72,37.04 55.16,37.49 U9.30
  IN1 w0.089: v2(54.72,36.46) 53.98,36.46 53.42,37.02 53.42,37.65 53.22,37.86 51.49,37.86 50.95,37.31 48.28,37.31 46.38,39.22 39.87,39.22 38.05,37.39 37.66,37.39 37.59,37.46 37.59,37.64 38.86,38.91 38.86,39.03 38.67,39.22 38.55,39.22 37.22,37.9 37.1,37.9 36.91,38.09 36.91,38.22 38.23,39.54 38.23,39.66 38.04,39.85 37.92,39.85 36.6,38.53 36.47,38.53 36.28,38.72 36.28,38.84 37.6,40.17 37.6,40.29 37.41,40.48 37.29,40.48 37.1,40.3 36.36,40.3 36.09,40.03 36.09,39.29 35.66,38.85 34.12,38.85 33.91,38.64 33.91,35.82 v2(33.51,35.42)
  BOTTOM w0.102: CN9.4 33.1,33.46 33.3,33.66 33.3,35.21 v2(33.51,35.42)
SD_CLK: length 47.2
  TOP w0.102: v2(60.05,40.93) 60,40.98 59.34,40.98 59.17,40.81 U9.17 ; v1(35.57,42.43) 35.54,42.43 v2(35.03,41.92)
  IN1 w0.089: v2(60.05,40.93) 60.36,40.93 61.04,40.25 61.04,39.38 60.66,39 60.66,34.79 59.11,33.24 57.35,33.24 55.13,35.46 55.13,36.64 54.87,36.89 54.31,36.89 53.75,37.45 53.75,37.78 53.36,38.17 51.25,38.17 50.76,37.68 48.4,37.68 46.46,39.61 38.75,39.61 37.1,41.26 36.81,41.26 36.69,41.13 36.69,40.83 36.56,40.7 36.13,40.7 36,40.83 36,41.62 35.7,41.92 v2(35.03,41.92)
  BOTTOM w0.102: CN9.7 33.18,39.08 33.36,39.26 33.36,40.93 34.65,42.19 C524.1 v2(35.03,41.92)
SD_CMD: length 44.7
  TOP w0.102: U9.19 58.37,40.94 56.45,42.86 52.21,42.86 51.7,42.35 51.7,37.53 v2(51.77,37.45)
  IN1 w0.089: v2(51.77,37.45) 51.44,37.12 48.09,37.12 47.02,38.19 44.09,38.19 43.63,38.64 42.75,38.64 42.3,38.19 39.25,38.19 38.18,37.12 37.52,37.12 36.05,38.59 34.44,38.59 34.1,38.25 34.1,34.4 33.95,34.24 33.43,34.24 33.28,34.09 33.28,33.79 33.43,33.64 33.8,33.64 33.95,33.49 33.95,33.27 33.82,33.14 33.37,33.14 33.28,33.06 33.28,32.79 33.37,32.7 33.82,32.7 33.94,32.57 33.94,32.29 33.56,31.91 v2(33.56,30.87)
  BOTTOM w0.102: CN9.3 33.36,31.58 33.54,31.4 33.54,30.9 v2(33.56,30.87)
SD_D0: length 45.1
  TOP w0.102: v2(59.95,40.07) 59.97,40.07 60.33,39.7 60.33,39.56 60.26,39.49 U9.16
  IN1 w0.089: v2(59.95,40.07) 60.33,39.69 60.33,35.7 59.57,34.94 56.12,34.94 55.6,35.46 55.6,36.63 55.01,37.21 54.46,37.21 54.08,37.59 54.08,38.06 53.65,38.49 52.43,38.49 52.26,38.67 52.26,38.96 52.11,39.1 51.91,39.1 51.77,38.96 51.77,38.68 51.61,38.52 51.38,38.52 51.21,38.68 51.21,38.98 51.07,39.13 50.86,39.13 50.71,38.98 50.71,38.17 50.57,38.04 50.38,38.04 50.24,38.17 50.24,38.76 50.15,38.85 49.88,38.85 49.8,38.76 49.8,38.1 49.71,38.01 49.44,38.01 49.35,38.1 49.35,38.76 49.26,38.85 49,38.85 48.91,38.76 48.91,38.1 48.82,38.01 48.55,38.01 48.46,38.1 48.46,38.31 48.33,38.44 48.15,38.44 46.66,39.93 38.9,39.93 35.94,42.89 35.57,42.89 35.42,42.73 35.42,42.59 35.29,42.47 34.83,42.47 34.7,42.59 34.7,42.71 34.58,42.84 v2(33.54,42.84)
  BOTTOM w0.102: v2(33.54,42.84) 33.54,43.65 33.18,44 CN9.9
SD_D1: length 44.4
  TOP w0.102: U9.15 60.34,39.09 60.61,39.36 v2(60.61,40.07)
  IN1 w0.089: v2(33.64,45.78) 33.41,45.78 33.28,45.66 33.28,43.93 33.41,43.8 34.12,43.8 34.25,43.93 34.25,44.41 34.35,44.51 34.59,44.51 38.91,40.19 46.95,40.19 48.08,39.06 48.08,38.83 48.21,38.7 48.39,38.7 48.52,38.83 48.52,39.06 48.61,39.15 50.05,39.15 50.27,39.38 53.22,39.38 54.34,38.26 54.34,37.68 54.59,37.43 55.15,37.43 55.79,36.79 55.79,35.62 56.19,35.22 59.52,35.22 60.08,35.77 60.08,39.36 59.55,39.89 59.55,40.3 59.72,40.47 60.21,40.47 v2(60.61,40.07)
  BOTTOM w0.102: CN9.10 33.61,45.75 v2(33.64,45.78)
SD_D2: length 44.2
  TOP w0.102: U9.21 57.57,41.17 56.33,42.4 53.17,42.4 52.1,41.34 52.1,38.24 52.41,37.93 52.54,37.93 v2(53.02,37.46)
  IN1 w0.089: v2(53.02,37.46) 52.3,36.74 47.86,36.74 46.9,37.71 43.14,37.71 41.99,36.55 37.52,36.55 36.53,37.55 34.73,37.55 34.48,37.3 34.48,31.96 34.22,31.7 34.22,30.24 33.54,29.55 v2(33.54,27.7)
  BOTTOM w0.102: CN9.1 33.36,26.58 33.54,26.76 v2(33.54,27.7)
SD_D3: length 44.3
  TOP w0.102: v2(52.4,37.45) 51.9,37.95 51.9,41.87 v1(52.31,42.28) 52.66,42.63 56.39,42.63 57.97,41.06 U9.20
  IN1 w0.089: v2(52.4,37.45) 51.88,36.93 47.95,36.93 46.95,37.93 41.87,37.93 41.78,37.84 41.78,37.38 41.66,37.25 41.47,37.25 41.34,37.38 41.34,37.84 41.25,37.93 40.98,37.93 40.9,37.84 40.9,37.34 40.77,37.21 40.58,37.21 40.45,37.34 40.45,37.84 40.36,37.93 39.8,37.93 38.79,36.93 37.41,36.93 36.44,37.9 34.69,37.9 34.29,37.5 34.29,32.17 33.97,31.84 33.97,30.64 v2(33.54,30.21)
  BOTTOM w0.102: v2(33.54,30.21) 33.49,30.16 33.49,29.26 33.31,29.08 CN9.2
SD_WP: length 44.5
  TOP w0.102: U9.29 54.79,37.89 v2(54.77,37.86)
  IN1 w0.089: v2(54.77,37.86) 54.77,39.36 54.5,39.62 50.11,39.62 49.87,39.38 48.95,39.38 48.86,39.47 48.86,40.09 48.73,40.22 48.55,40.22 48.42,40.09 48.42,39.47 48.33,39.38 48.06,39.38 47.97,39.47 47.97,40.01 46.93,41.06 46.23,41.06 46.14,41.15 46.14,41.73 46.05,41.82 45.79,41.82 45.7,41.73 45.7,40.65 45.57,40.52 45.38,40.52 45.25,40.65 45.25,41.73 45.17,41.82 44.9,41.82 44.81,41.73 44.81,40.7 44.68,40.58 44.49,40.58 44.37,40.7 44.37,41.73 44.28,41.82 44.01,41.82 43.92,41.73 43.92,40.8 43.79,40.68 43.6,40.68 43.48,40.8 43.48,41.73 43.39,41.82 43.12,41.82 43.03,41.73 43.03,40.75 42.9,40.63 42.71,40.63 42.59,40.75 42.59,41.73 42.5,41.82 42.23,41.82 42.14,41.73 42.14,41.15 42.05,41.06 40.06,41.06 39.97,41.15 39.97,41.78 39.88,41.87 39.62,41.87 39.53,41.78 39.53,41.15 39.44,41.06 39.17,41.06 39.08,41.15 39.08,41.78 38.99,41.87 38.73,41.87 38.64,41.78 38.64,41.15 38.55,41.06 38.31,41.06 34.15,45.22 34.15,47.48 v2(33.82,47.81)
  BOTTOM w0.102: CN9.11 33.81,47.81 v2(33.82,47.81)
SDIO_CK: length 21.6
  TOP w0.102: v2(157.87,99.55) 158.68,99.55 160.16,101.03 160.46,101.03 163.15,103.72 168.77,103.72 171.48,106.44 171.48,106.59 172.02,107.12 v1(173.95,107.12) 174.07,107.25 RP3.4
  BOTTOM w0.076: U14.E3 158.34,99.55 v2(157.87,99.55)
SDIO_CMD: length 20.7
  TOP w0.102: v2(158.49,98.64) 158.49,98.83 160.21,100.54 160.49,100.54 163.46,103.52 168.85,103.52 171.69,106.35 171.69,106.5 171.95,106.76 172.61,106.76 v1(172.78,106.59) RP3.2
  BOTTOM w0.076: v2(158.49,98.64) 158.19,98.34 U14.F4
SDIO_D0: length 13.3
  BOTTOM w0.076: U14.D3 158.84,99.52 158.99,99.37 159.61,99.37 159.78,99.54 159.78,99.99 160.01,100.21 160.31,100.21 160.56,100.46
  BOTTOM w0.102: R299.1 167.17,103.55 v1(165.87,103.55) 165.84,103.52 165.84,102.61 R300.2 165.32,102.6 164.84,103.08 162.47,103.08 160.79,101.41 160.79,100.69 160.56,100.46
SDIO_D1: length 22.8
  TOP w0.102: v2(157.08,99.5) 157.08,99.74 158.67,101.33 159.16,101.33 161.96,104.13 168.57,104.13 171.08,106.64 171.08,107.4 172.33,108.66 RP1.4 v1(172.96,109.45)
  BOTTOM w0.102: U14.E4 157.94,98.8 157.36,98.8 157.08,99.07 v2(157.08,99.5)
SDIO_D2: length 17.9
  TOP w0.102: v2(160.27,101.55) 160.27,102 162.19,103.92 168.68,103.92 171.28,106.52 171.28,106.92 v1(172.02,107.66) 172.37,108.01 RP1.2
  BOTTOM w0.076: 158.98,100.44 159.38,100.84 159.8,100.84 160.19,101.23 160.19,101.24
  BOTTOM w0.102: v2(160.27,101.55) 160.27,101.32 160.19,101.24
  BOTTOM w0.305: 158.98,100.44 U14.C3
SDIO_D3: length 6.7
  BOTTOM w0.076: 160.56,99.33 160.56,99.17 160.28,98.89 160.01,98.89 159.88,99.01 U14.E2
  BOTTOM w0.102: 160.56,99.33 160.56,99.45 161.09,99.98 161.09,101.42 162.29,102.62 R298.1
SENSE_A: length 6.5
  TOP w0.254: v2(303.67,28.43) 303.67,28.46 303.3,28.82 R261.2 303.13,29.73 303.56,30.15 U10.13
  BOTTOM w0.254: v2(303.67,28.43) 303.34,28.76 v1(302.93,28.76) 302.93,27.88 303.02,27.79 303.02,27.15 302.48,26.61 R526.2
SENSE_COMBO: length 23
  TOP w0.254: R261.1 303.13,27.95 303.63,27.46 303.63,27.18 v2(303.65,27.15)
  BOTTOM w0.254: v2(303.65,27.15) 303.65,27.11 304.74,26.03 C523.1 307.79,26.03 v1(307.93,26.16) 308.19,26.42 308.19,27.52 310.7,30.03 310.99,30.03 311.72,30.76 314.55,30.76 315.74,29.57 315.74,28.27 316.61,27.4 CN12.5
SENSE_JACK: length 15.7
  BOTTOM w0.254: R526.1 303.64,26.03 303.83,26.03 304.57,25.3 307.96,25.3 308.82,26.16 308.82,26.48 311.15,28.8 311.45,28.8 311.77,29.12 311.77,29.75 312.14,30.12 313.1,30.12 313.28,29.94 Q48.3
SENSOR_HUB_INT: length 18.5
  TOP w0.102: R84.1 172.56,82.41 172.38,82.59 172.38,83.25 v1(171.93,83.7) 170.83,83.7 169,85.53 168.55,85.53 167.94,86.14 167,86.14 166.64,85.79 164.23,85.79 163.75,85.3 162.51,85.3 161.9,85.91 160.16,85.91 159.89,86.19 157.86,86.19 v2(157.7,86.35)
  BOTTOM w0.076: v2(157.7,86.35) 157.81,86.24 U14.AH4
SENSOR_STANDBY_N: length 12.3
  BOTTOM w0.076: 158.2,100.65 158.35,100.65 158.46,100.75 159.04,100.75 159.24,100.95 159.24,101.42 159.45,101.62 159.45,101.99
  BOTTOM w0.102: 159.45,101.99 159.63,102.17 160.94,102.17 162.34,103.57 163.74,103.57 164.3,104.13 v1(167.02,104.13) 167.74,104.13 R297.1
  BOTTOM w0.305: U14.C4 158.2,100.65
SIO_EXT_SCI#: length 81.1
  IN3 w0.114: v2(166.38,86.4) 166.38,87.56 170.58,91.77 170.58,92.34 170.14,92.78 170.14,93.69 170.52,94.07 174.13,94.07 175.06,93.14 175.06,93.14 175.57,92.63 175.69,92.5 175.69,89.59 175.54,89.43 175.54,82.55 175.83,82.25 175.83,74.87 174.99,74.03 173.87,74.03 v2(172.75,72.91)
  BOTTOM w0.076: 161.63,84.47 160.48,84.47 160.33,84.32 160.02,84.32 159.73,84.03 U14.AM2
  BOTTOM w0.102: 161.63,84.47 161.63,84.47 162.23,84.47 162.91,85.15 164.98,85.15 165.19,85.37 166.57,85.37 166.74,85.54 R352.1 166.74,86.03 v2(166.38,86.4) ; v2(172.75,72.91) 173.17,72.49 176.6,72.49 176.81,72.27 177.73,72.27 183.37,66.63 183.37,65.78 186.18,62.98 187.52,62.98 190.86,59.63 190.86,54.7 192.31,53.25 192.31,52.72 v1(193.04,51.99) 193.43,51.6 194.22,51.6 194.39,51.42 D11.2
SIO_PWRBTN#: length 141.4
  TOP w0.076: v2(156.8,85.28) 156.8,84.73 157.23,84.3 157.23,83.88 157.39,83.73 157.39,81.88 158.22,81.04 158.22,80.33
  TOP w0.102: R121.1 159.16,72.77 159.21,72.82 159.21,73.4 159.42,73.61 v1(159.42,74.1) 159.42,77.3 159.09,77.63 159.09,79.46 158.22,80.33
  IN1 w0.076: v2(156.8,85.28) 157.07,85.55 157.97,85.55
  IN1 w0.089: 157.97,85.55 159.31,85.55 159.71,85.15 159.71,83.38 162.24,80.86 162.24,77.79 163.55,76.48 163.55,74.93 163.9,74.58 163.9,72.2 165.68,70.41 165.68,69.3 181.18,53.8 181.18,50.01 182.82,48.36 182.82,45.93 182.82,45.65 182.82,44.23 183.17,43.88 183.17,42.59 196.16,29.59 199.8,29.59 201.12,28.27 209.3,28.27 209.48,28.08 221.4,28.08 222.89,29.58 231.22,29.58 231.75,30.1 234.51,30.1 234.96,29.66 238.57,29.66 240.39,31.48 v2(240.39,31.86)
  BOTTOM w0.102: U14.AL7 156.48,84.96 v2(156.8,85.28) ; v2(240.39,31.86) 240.39,33.06 240.6,33.26 240.6,35.93 241.41,36.74 D20.2
SIO_RCIN#: length 109.9
  TOP w0.102: v1(186.56,43.63) 186.56,44.37 v2(186.52,44.41) ; R53.1 164.24,91.73 160.38,91.73 159.39,90.74 158.91,90.74 v2(158.5,91.15)
  IN1 w0.089: v2(158.5,91.15) 159.08,91.72 159.88,91.72 160.8,92.65 163.31,92.65 164.66,91.29 164.66,89.4 168.33,85.73 169.1,85.73 170.4,84.43 170.86,84.43 172.21,83.08 172.21,78.05 170.76,76.6 170.76,71.43 172.25,69.94 172.25,66.98 184.91,54.32 184.91,50.76 185.91,49.76 185.91,46.18 186.36,45.74 186.36,44.57 v2(186.52,44.41)
  BOTTOM w0.076: U14.V4 158.19,91.46 v2(158.5,91.15)
  BOTTOM w0.102: D21.2 210.77,31.48 206.66,35.6 195.74,35.6 194.73,34.58 193.78,34.58 193.33,34.13 190.73,34.13 187.31,37.56 187.31,41.04 186.77,41.57 186.77,44.16 v2(186.52,44.41)
SIO_SLP_S3#: length 178.1
  TOP w0.102: v1(114.92,60.79) 113.77,59.65 R142.1 ; v1(114.92,60.79) 114.05,60.79 113.64,61.21 PR32.1 ; v1(114.92,60.79) 115.04,60.79 115.15,60.69 117.33,60.69 v2(117.46,60.57)
  IN1 w0.089: v2(117.46,60.57) 117.64,60.75 117.64,62.32 118.65,63.33 118.65,63.79 121.78,66.92 121.78,68.82 v2(120.76,69.84) ; v2(223.12,29.02) 221.72,27.61 209.29,27.61 209.11,27.8 200.92,27.8 199.92,28.8 196.29,28.8 182.63,42.46 182.63,43.75 182.35,44.03 182.35,48.17 180.71,49.81 180.71,53.61 165.21,69.11 165.21,70.22 163.08,72.35 163.08,76.29 161.77,77.6 161.77,80.09 161.32,80.54 160.11,80.54 v2(158.49,82.15)
  IN3 w0.114: v2(158.49,82.15) 158.01,81.67 157.69,81.67 157.31,81.29 156.04,81.29 155.79,81.04 155.79,80.76 155.28,80.25 154.59,80.25 154.41,80.43 154.41,84.11 153.27,85.25 152.53,85.25 152.26,85.52 152.05,85.73 152.05,86.76 151.56,87.24 148.82,87.24 148.53,87.53 147.11,87.53 146.71,87.93 135.03,87.93 133.97,87.93 132.52,86.47 131.5,86.47 131.25,86.22 131.25,85.56 131.1,85.41 130.52,85.41 129.12,84.01 128.15,84.01 127.57,83.43 127.57,81.93 124.52,78.88 124.52,78.1 121.17,74.75 121.17,73.84 118.32,71 118.32,70.11 118.68,69.75 120.68,69.75 v2(120.76,69.84)
  BOTTOM w0.102: U14.AT4 158.19,81.85 v2(158.49,82.15) ; U23.124 223.09,29.05 v2(223.12,29.02)
SIO_SLP_S4#: length 239.3
  TOP w0.102: v2(220.79,29.3) 220.99,29.5 v1(220.99,31.36) 220.99,32.4 221.01,32.42 v2(221.01,32.45) ; v2(107.63,43.62) 107.3,43.95 Q19.2 ; PR66.2 171.15,33.77 171.33,33.95 175.06,33.95 176.38,32.63 178.32,32.63 178.98,31.96 180.9,31.96 181.3,31.57 183.45,29.41 183.45,26.02 182.91,25.49 182.91,24.85 184.16,23.61 186.99,23.61 187.28,23.9 187.28,29.12 187.33,29.17 187.33,39.56 v2(186.22,40.68)
  IN1 w0.076: v2(156.4,86.35) 156.42,86.35 156.85,85.91 157.82,85.91 157.97,86.06
  IN1 w0.089: 157.97,86.06 158.05,86.14 159.38,86.14 160.18,85.34 160.18,83.58 162.71,81.05 162.71,77.99 164.02,76.68 164.02,75.22 164.7,74.54 164.7,72.05 166.15,70.61 166.15,69.5 181.65,54 181.65,53.61 181.65,53.61 181.65,50.2 183.29,48.56 183.29,45.74 183.29,45.45 183.29,45.45 183.29,45.17 183.29,44.42 183.64,44.08 183.64,43.25 v2(186.22,40.68) 186.42,40.47 186.42,40 196.28,30.14 200.52,30.14 201.93,28.74 209.49,28.74 209.68,28.55 220.26,28.55 220.79,29.08 v2(220.79,29.3)
  IN3 w0.114: v2(107.63,43.62) 107.63,43.77 109.73,45.87 110.09,46.24 110.09,48.18 115.14,53.23 115.14,61.77 114.96,61.95 114.96,66.85 115.91,67.8 115.91,72.22 121.13,77.44 121.13,78.8 121.51,79.18 121.51,81.95 123.55,84 124.58,84 124.8,84.21 124.8,84.66 126.85,86.71 129.65,86.71 130.37,87.43 130.55,87.43 132.95,89.83 143.39,89.83 144.09,89.13 146.87,89.13 147.6,88.4 148.89,88.4 149.18,88.1 152.2,88.1 152.57,87.73 154.48,87.73 155.59,86.62 156.13,86.62 v2(156.4,86.35)
  BOTTOM w0.102: U14.AJ6 156.4,86.34 v2(156.4,86.35) ; v2(221.01,32.45) 221.01,33.64 220.75,33.91 220.75,38.9 220.56,39.09 U23.19
SIO_SLP_S5#: length 126
  TOP w0.102: v2(169.63,60.69) 172.05,60.69 173.21,59.52 181.11,59.52 182.64,57.99 191.44,57.99 191.85,58.41 193.28,58.41 196.02,55.66 196.02,51.12 v1(195.61,50.71) 195.36,50.46 195.36,47.96 200.05,43.27 225.13,43.27 226.6,44.74 230.41,44.74 231.78,43.37 235.21,43.37 237.47,41.11 239.43,41.11 241.21,42.89 241.21,44.54 241.79,45.12 243.54,45.12 244.04,44.63 v2(244.04,44.57) ; v2(160.1,78.01) 159.6,78.52 159.6,82.27 159.08,82.79 158.66,82.79 157.82,83.63 v2(157.79,83.63)
  IN2 w0.114: v2(169.63,60.69) 166.28,60.69 165.21,61.76 165.21,70.99 164.97,71.23 162.08,71.23 161.48,71.83 161.48,76.64 v2(160.1,78.01)
  BOTTOM w0.102: v2(157.79,83.63) 157.79,83.55 157.26,83.01 U14.AP5 ; v2(244.04,44.57) 244.04,44.53 243.82,44.31 D15.2
SIO_SLP_S5#_R: length 4.2
  BOTTOM w0.102: v1(245.35,41.36) 243.59,41.36 D15.1 243.19,41.14 243.83,40.5 R459.2
SIO_WAKE_SCI#: length 15.8
  TOP w0.076: 158.22,84.14 157.89,84.14 157.74,84.29 157.77,84.31 v2(157.77,84.36)
  TOP w0.102: R124.1 161.78,73.25 162.06,73.53 v1(162.06,74) 162.06,75.43 162.64,76.02 162.64,76.35 161.76,77.24 161.76,78.35 161.3,78.8 161.3,82.26 160.59,82.97 160.36,82.97 159.55,83.78 159.55,83.82 159.23,84.14 158.22,84.14
  BOTTOM w0.102: v2(157.77,84.36) 157.77,84.31 157.24,83.79 U14.AN5
SLATE_MODE_HALL_IN: length 15.7
  TOP w0.102: v2(158.49,85.15) 158.92,84.72 159.44,84.72 160.28,83.88 160.28,83.84 160.57,83.55 160.8,83.55 161.86,82.49 161.86,79.03 162.31,78.58 162.31,78.14 163.46,77 v1(163.46,75.73) 162.8,75.07 R125.1
  BOTTOM w0.102: U14.AL4 158.19,84.85 v2(158.49,85.15)
SLP_S0#: length 106.3
  TOP w0.102: R183.2 214.73,37.59 214.99,37.32 216.01,37.32 216.26,37.07 216.26,35.84 214.03,33.61 214.03,30.17 213.16,29.3 v2(208.44,29.3)
  IN1 w0.089: v2(161.88,88.71) 163.62,86.97 163.62,83.77 163.05,83.2 163.05,78.13 164.36,76.82 164.36,75.36 165.04,74.68 165.04,72.2 166.49,70.75 166.49,69.64 182.09,54.05 182.09,50.25 183.64,48.7 183.64,44.56 184.03,44.17 184.03,43.61 187.05,40.6 187.05,39.86 192.32,34.58 193.4,34.58 197.5,30.49 200.66,30.49 201.38,29.77 206.06,29.77 206.69,29.15 208.29,29.15 v2(208.44,29.3)
  BOTTOM w0.076: v2(161.88,88.71) 161.51,88.71 161.5,88.71 161.35,88.71 161.03,88.39 161.03,87.88 160.8,87.65 160.44,87.65 160.26,87.48 159.1,87.48 U14.AF3
SLP_S0#_R: length 6.8
  TOP w0.102: v2(218.4,39.03) 218.4,39.39 217.29,40.5 216.15,40.5 R182.1 R183.1
  BOTTOM w0.102: U23.20 218.86,39.49 v2(218.4,39.03)
SM_INTRUDER#: length 12.3
  TOP w0.102: v2(157.64,80.94) 157.64,80.22 158.1,79.77 158.1,77.94 158.91,77.13 158.91,73.92 157.75,72.77 v1(157.03,72.77) R120.2
  BOTTOM w0.076: v2(157.64,80.94) 157.52,81.06 U14.AU6
SM_RCOMP_0: length 7.1
  TOP w0.305: v2(123.63,81.61) 123.63,81.61 123.63,81.31 124.57,80.37 R112.2 125.32,76.96 v1(125.84,76.44)
  BOTTOM w0.178: U14.AU60 123.58,81.36 123.63,81.41 123.63,81.61 v2(123.63,81.61)
SM_RCOMP_1: length 6.3
  TOP w0.305: v1(123.63,74.97) 123.63,76.59 123.25,76.97 R111.2 122.97,77.05 122.97,80.13 v2(123.08,80.24)
  BOTTOM w0.178: v2(123.08,80.24) 123.25,80.41 U14.AV60
SM_RCOMP_2: length 7.5
  TOP w0.305: v1(120.46,76.21) 121.22,76.97 R110.2 121.9,77.48 121.42,77.96 121.42,80.56 v2(122.39,81.53)
  BOTTOM w0.178: v2(122.39,81.53) 122.67,81.53 U14.AU61
SM_VREF_CA: length 109.2
  TOP w0.102: R198.2 163.82,37.33 v2(164.55,38.06) 164.7,38.06 v1(165.26,37.5)
  IN3 w0.114: v2(164.55,38.06) 164.04,37.55 156.37,37.55 156.04,37.88 154.87,37.88 154.69,38.06 154.69,38.95 154.36,39.28 153.3,39.28 151.62,37.6 138.88,37.6 138.69,37.6 138.5,37.6 138.5,37.6 138.04,37.6 137.35,36.92 119.77,36.92 119.12,37.57 113.91,37.57 112.3,39.18 112.3,42.99 112.84,43.52 112.84,45.68 117.99,50.84 117.99,62.79 118.17,62.97 118.17,65 123.43,70.26 123.43,72.87 126.66,76.1 126.66,77.91 129.45,80.7 129.45,82.31 129.71,82.57 v2(129.94,82.57)
  BOTTOM w0.254: v2(129.94,82.57) 130.09,82.57 U14.AP49
SM_VREF_DQ1: length 44
  TOP w0.508: v2(117.48,52.82) 117.2,52.82 116.57,52.18 v1(116.57,51.55) 116.31,51.8 113.39,51.8 112.89,51.29 R152.2
  IN1 w0.508: v2(117.48,52.82) 117.89,52.82 122.62,57.55 122.62,70.29 122.11,70.8 122.11,72.88 121.34,73.65 121.34,75.93 122.84,77.43 122.84,78.5 125.81,81.47 127.19,81.47 128.26,82.55 v2(128.99,82.55)
  BOTTOM w0.254: v2(128.99,82.55) 129.32,82.87 U14.AP51
SMB3_CLK2_Q: length 7.2
  TOP w0.102: v1(174.22,62.99) RP8.1 174.76,63.92 174.88,63.81 174.88,63.28 175.08,63.08 Q15.4 175.35,63.8 175.5,63.94 177.1,63.94 177.38,63.66 177.38,63.31 177.54,63.15 U4.8
SMB3_CLK_Q: length 11
  TOP w0.102: v2(116.06,65.26) 115.81,65.26 115.3,64.76 115.3,63.48 114.85,63.03 ; Q17.4 118.29,62.58 118.09,62.39 118.09,62.09 117.73,61.73 v1(116.54,61.73) 116.16,61.73 114.85,63.03 ; v2(116.06,66.41) 116.06,67.15 115.83,67.38 U3.8 ; 114.85,63.03 RP9.1
  BOTTOM w0.102: v2(116.06,66.41) v2(116.06,65.26)
SMB3_DATA2_Q: length 7.3
  TOP w0.102: v1(173.92,65.57) 174.22,65.27 RP8.3 174.89,64.57 175.17,64.3 176.58,64.3 176.65,64.37 Q15.1 176.97,65.16 177.33,64.81 177.33,64.1 177.63,63.8 U4.7
SMB3_DATA_Q: length 7.8
  TOP w0.102: v1(115.17,65.39) 114.74,65.83 U3.7 ; v1(115.17,65.39) 115.02,65.24 115.02,63.88 114.82,63.68 RP9.3 ; v1(115.17,65.39) 115.55,65.77 116.57,65.77 116.93,65.41 Q17.1
SMB_CLK0: length 7.4
  IN1 w0.089: v2(162.75,83.91) 163.28,84.44 163.28,86.65 162.95,86.98 v2(162.92,86.98)
  BOTTOM w0.076: U14.AN1 161.38,83.28 161.63,83.53
  BOTTOM w0.102: 161.63,83.53 161.65,83.53 162.03,83.91 v2(162.75,83.91) ; v2(162.92,86.98) 163.25,87.31 RP21.3
SMB_CLK_ME1: length 29.7
  BOTTOM w0.076: 158.83,80.85 158.49,80.52 158.49,79.62 158.55,79.56 158.55,78.84 159.27,78.12 159.27,77.79 159.49,77.56 162.8,77.56
  BOTTOM w0.102: 162.8,77.56 163.75,77.56 165.96,75.35 167.29,75.35 167.47,75.17 167.47,74.87 167.65,74.69 168.46,74.69 168.64,74.51 168.64,69.91 168.82,69.73 169.32,69.73 169.5,69.91 v1(169.5,72.73) 169.5,74.81 169.65,74.97 169.65,75.96 170.27,76.57 RP23.3 170.98,76.09 170.88,75.99 170.78,75.99 170.53,75.74 Q37.4
  BOTTOM w0.305: U14.AU3 158.83,80.85
SMB_DAT0: length 4.7
  BOTTOM w0.076: 161.63,85.79 161.3,85.79 161.16,85.65 160.27,85.65 U14.AK1
  BOTTOM w0.102: RP21.1 163.41,86.66 163.28,86.52 163.28,85.84 163.1,85.66 162.39,85.66 162.26,85.79 161.63,85.79
SMB_DATA_ME1: length 36
  IN3 w0.114: v2(161.45,87.01) 162.07,87.63 163.67,87.63 165.33,85.97 166.55,85.97 167.98,87.39 169.41,87.39 169.76,87.74 v2(169.78,87.74)
  BOTTOM w0.076: U14.AH3 159.1,85.98 159.61,85.98 159.85,86.22 159.85,86.4 160.02,86.57 160.26,86.57 160.39,86.44 160.96,86.44 161.43,86.9 161.43,86.98 v2(161.45,87.01)
  BOTTOM w0.102: v2(169.78,87.74) 169.76,87.74 169.78,87.77 169.81,87.77 170.22,87.35 170.22,85.09 171.71,83.6 174.13,83.6 174.43,83.3 174.43,82.19 174.99,81.63 174.99,78.5 v1(175.55,77.94) 175.55,77.35 174.91,76.72 171.78,76.72 RP23.1 171.63,76.24 171.64,76.24 171.64,76.05 171.71,75.97 171.9,75.97 172.19,75.68 172.19,74.21 171.83,73.85 Q37.1
SMB_INT#: length 82.8
  IN3 w0.114: v2(172.96,90.45) 173.56,89.85 173.56,89.48 173.43,89.35 173.43,85.61 174.05,84.99 174.05,81.67 173.69,81.32 173.69,76.08 168.21,70.6 168.21,67.47 165.07,64.34 165.07,54.91 174.13,45.85 174.59,45.85 176.02,44.41 178.2,44.41 179.44,43.17 181.08,43.17 v2(181.21,43.04)
  BOTTOM w0.102: R333.1 R329.1 171.41,90.41 172.01,91.01 172.66,91.01 172.96,90.71 v2(172.96,90.45) ; v2(181.21,43.04) 181.21,41.64 181.85,41.01 181.85,39.51 182.53,38.82 182.53,29.67 182.71,29.49 v1(183.28,29.49) 184.9,27.88 CN15.7
SMB_PCH_CLK: length 78
  TOP w0.102: R248.1 184.89,30.31 185.17,30.59 185.17,32.05 183.33,33.9 179.24,33.9 178.44,34.69 178.44,37.79 v2(178.2,38.03) 177.73,38.5 177.73,40.85 177.2,41.39 177.2,42.33 v2(176.84,42.68)
  IN3 w0.114: v2(176.84,42.68) 176.39,42.68 174.19,44.88 173.55,44.88 164.1,54.32 164.1,55.27 164.11,65.01 166.84,67.74 166.84,70.79 168.75,72.71 168.75,74.13 169.58,74.96 170.31,74.96 172.7,77.35 172.7,81.76 173.08,82.14 173.08,83.73 171.84,84.97 171.84,85.56 172.27,85.99 v2(172.27,87.16)
  BOTTOM w0.102: Q34.4 173.7,86.81 173.43,86.54 RP22.1 172.57,87.04 172.45,87.16 v2(172.27,87.16) ; v2(178.2,38.03) 178.31,37.92 JDIM1.202
SMB_PCH_DAT: length 79.9
  TOP w0.102: R249.1 185.91,30.23 185.53,30.61 185.53,32.19 183.47,34.25 179.38,34.25 178.8,34.83 178.8,38.11 v2(178.2,38.71) 178.09,38.82 178.09,41 177.55,41.54 177.55,42.56 v2(177.68,42.68)
  IN3 w0.114: v2(172.32,85.2) 172.32,85.01 173.45,83.88 173.45,81.99 173.07,81.61 173.07,77.2 170.46,74.59 169.74,74.59 169.12,73.98 169.12,72.55 167.2,70.64 167.2,67.59 164.47,64.86 164.47,55.12 164.47,55.12 164.47,54.47 173.7,45.25 174.34,45.25 175.81,43.78 177.02,43.78 177.25,43.55 177.25,43.12 v2(177.68,42.68)
  BOTTOM w0.102: Q34.1 175,84.53 174.81,84.34 173.44,84.34 173.11,84.67 173.11,85.63 172.85,85.89 RP22.3 172.32,85.65 v2(172.32,85.2) ; v2(178.2,38.71) 177.71,38.22 JDIM1.200
SMBCLK: length 22.8
  BOTTOM w0.076: 161.63,82.49 160.51,82.49 160.26,82.24 160.02,82.24 159.73,82.53 U14.AP2
  BOTTOM w0.102: Q34.3 173.7,86.28 173.98,86.56 173.98,87.96 173.9,88.04 RP20.3 173.47,88.51 172.55,87.59 172.09,87.59 171.66,87.16 170.98,87.16 169.91,88.23 169.32,88.23 167.93,86.83 167.93,85.55 168.08,85.41 168.08,84.97 167.72,84.62 165.62,84.62 165.44,84.44 164.83,84.44 162.88,82.49 161.63,82.49
SMBCLK0: length 241.7
  TOP w0.102: v2(52.51,28.74) 52.13,28.74 51.96,28.9 PR70.2 ; RP10.3 230.05,33.59 v1(229.87,33.4) 229.65,33.18 229.65,30.22 228.58,29.15 v2(228.58,29.02)
  IN1 w0.089: v2(27.99,12.86) 27.76,12.86 27.4,13.23 27.4,13.71 28.57,14.88 30.5,14.88 34.44,18.82 47.5,18.82 50.24,21.56 50.24,26.26 51.37,27.39 51.37,30.18 51.69,30.5 52.55,30.5 52.61,30.44 52.61,28.84 v2(52.51,28.74)
  IN3 w0.114: v2(228.58,29.02) 228.16,28.59 227.75,28.59 226.83,27.67 226.61,27.46 226.31,27.46 226.31,27.46 221.14,27.46 221.04,27.35 210.55,27.35 209.81,28.09 209.53,28.09 209.23,28.09 209.04,28.28 200.04,28.28 199.23,29.09 199.12,29.2 198.49,29.83 197.78,29.83 197.78,29.83 196.37,29.83 193,29.83 192.57,30.26 192.35,30.48 190.97,31.86 185.63,31.86 181.35,36.14 153.4,36.14 152.97,35.71 138.68,35.71 138.1,35.13 119.03,35.13 118.38,35.78 110.19,35.78 102.42,28.01 92.43,28.01 90.69,26.28 90.09,26.28 90.09,26.28 89.95,26.28 88.21,24.54 85.81,24.54 85.01,23.74 76.4,23.74 76,23.34 67.84,23.34 66.02,25.16 56.6,25.16 54.83,26.92 53.17,26.92 52.57,27.52 52.57,28.68 v2(52.51,28.74)
  BOTTOM w0.102: U23.110 228.69,29.13 v2(228.58,29.02) ; ESD6.4 28.82,15.03 27.77,13.98 27.77,13.08 v2(27.99,12.86) 27.99,11.98 PR203.2
SMBCLK1: length 92.3
  TOP w0.102: RP11.1 225.54,35.33 225.71,35.5 225.71,35.88 v2(225.79,35.95)
  IN3 w0.114: v2(225.79,35.95) 225.74,35.95 224.91,35.13 218.77,35.13 218.49,34.85 216.04,34.85 214.56,36.32 213.95,36.32 213.7,36.07 210.2,36.07 209.89,36.37 201.19,36.37 200.84,36.73 198.49,36.73 194.8,40.42 192.75,40.42 191.13,42.04 190.9,42.04 187.18,45.76 187.18,49.54 189.04,51.4 190.41,51.4 v2(190.69,51.12)
  BOTTOM w0.102: v2(225.79,35.95) 225.8,35.95 225.81,35.94 225.81,35.52 225.66,35.37 225.66,34.48 226.2,33.95 226.2,32.78 226.66,32.32 226.66,31.39 226.65,31.39 226.65,31.17 226.69,31.13 U23.115 ; Q37.3 170.53,72.34 171.94,70.93 176.7,70.93 181.62,66.01 181.62,65.19 189.14,57.67 189.14,53.89 190.38,52.65 190.58,52.44 190.58,51.22 v2(190.69,51.12)
SMBCLK3: length 240.1
  TOP w0.102: v2(264.85,36.93) 264.96,37.03 264.96,37.25 264.37,37.83 262.49,37.83 259.33,40.99 259.33,41.58 259.23,41.68 259.04,41.68 258.94,41.78 R172.2 ; v2(237.37,31.2) 236.79,30.62 236.79,30.22 236.64,30.07 RP12.3 ; Q14.3 186.05,68.55 186.17,68.43 186.17,65.95 186.04,65.82 186.04,63.33 185.25,62.55 180.27,62.55 179.89,62.93 179.89,65.91 179.2,66.61 175.6,66.61 175.35,66.37 Q15.3 174.97,65.16 174.56,65.57 174.56,66.79 174.07,67.27 v1(172.6,67.27) 172.6,65.53 v2(168.74,61.66) 168.74,62.04 168.74,62.04 168.74,65.04 165.49,68.29 161.89,68.29 159.16,65.56 159.16,59.14 155.56,55.54 135.87,55.54 129.14,62.27 121.85,62.27 120.73,63.38 120.73,64.02 120,64.76 118.22,64.76 117.86,64.4 117.86,62.76 117.69,62.58 Q17.3
  IN3 w0.114: v2(264.85,36.93) 265.01,36.77 265.01,36.08 264.14,35.22 261.09,35.22 260.4,35.91 245.37,35.91 240.53,31.08 237.5,31.08 v2(237.37,31.2) 237.37,31.69 236.73,32.33 232.39,32.33 232.15,32.58 232.15,32.59 231.78,32.96 230.22,32.96 230.14,33.04 226.79,33.04 226.72,32.97 226.64,32.97 226.19,32.52 222.33,32.52 221.6,31.79 219.02,31.79 218.04,30.81 214.38,30.81 213.62,31.57 210.49,31.57 208.86,33.2 207.03,33.2 206.28,32.45 201.18,32.45 200.38,33.25 197.77,33.25 197.38,33.64 197.38,33.64 194.94,36.08 190.05,36.08 182.23,43.9 179.75,43.9 178.51,45.15 176.33,45.15 174.37,47.1 173.97,47.1 167.74,53.34 167.74,60.01 168.65,60.92 168.65,61.58 v2(168.74,61.66)
  BOTTOM w0.102: v2(237.37,31.2) 237.09,31.48 237.09,32.11 236.52,32.69 U23.94
SMBDAT0: length 242.8
  TOP w0.102: v2(53.15,28.74) 52.62,28.21 PR83.2 ; v2(227.95,29.02) 229.29,30.36 229.29,33.77 229.4,33.87 RP10.1
  IN1 w0.089: v2(24.76,13.46) 25.32,13.46 25.71,13.07 26.27,13.07 28.43,15.23 30.36,15.23 34.3,19.16 47.35,19.16 49.89,21.7 49.89,26.4 51.02,27.53 51.02,30.33 51.54,30.85 52.69,30.85 52.95,30.58 52.95,28.93 v2(53.15,28.74)
  IN3 w0.114: v2(53.15,28.74) 52.94,28.54 52.94,27.67 53.32,27.29 54.99,27.29 56.75,25.53 66.18,25.53 67.99,23.71 75.85,23.71 76.25,24.1 84.86,24.1 85.66,24.9 88.06,24.9 89.8,26.64 89.94,26.64 90.53,26.64 92.27,28.38 102.27,28.38 110.03,36.15 118.53,36.15 119.18,35.5 137.94,35.5 138.53,36.08 152.81,36.08 153.25,36.51 181.5,36.51 185.78,32.23 191.12,32.23 192.72,30.63 192.93,30.41 192.93,30.41 193.15,30.2 196.52,30.2 198.64,30.2 199.38,29.46 200.19,28.65 209.19,28.65 209.38,28.46 209.97,28.46 210.7,27.72 220.89,27.72 220.99,27.82 226.46,27.82 227.6,28.96 227.89,28.96 v2(227.95,29.02)
  BOTTOM w0.102: U23.111 228.29,29.36 v2(227.95,29.02) ; v1(24.49,14.13) 24.49,13.73 v2(24.76,13.46) PR202.2 25.51,13.9 26.64,15.03 ESD6.3
SMBDAT1: length 94.6
  TOP w0.102: v2(225.13,35.95) 225.13,35.42 224.87,35.17 224.87,34.48 225.02,34.33 RP11.3
  IN3 w0.114: v2(191.09,50.52) 190.64,50.52 190.14,51.03 189.19,51.03 187.55,49.39 187.55,45.91 191.05,42.41 191.28,42.41 192.9,40.79 194.95,40.79 198.65,37.1 200.99,37.1 201.35,36.74 210.04,36.74 210.35,36.44 213.55,36.44 213.8,36.69 214.71,36.69 216.19,35.22 218.34,35.22 218.62,35.5 224.76,35.5 225.17,35.91 v2(225.13,35.95)
  BOTTOM w0.102: U23.116 226.29,31.54 226.3,31.54 226.3,32.17 225.84,32.63 225.84,33.8 225.26,34.38 225.26,35.83 v2(225.13,35.95) ; Q37.6 171.83,74.3 171.48,73.95 171.48,72.07 172.27,71.28 176.84,71.28 181.97,66.15 181.97,65.34 189.49,57.82 189.49,54.04 190.52,53.01 190.94,52.59 190.94,51.7 191.24,51.4 191.24,50.68 191.09,50.53 v2(191.09,50.52)
SMBDAT3: length 235.1
  TOP w0.102: v2(265.51,36.89) 265.31,37.1 265.31,37.4 264.52,38.19 262.64,38.19 259.69,41.14 259.69,41.58 259.79,41.68 259.98,41.68 260.08,41.78 R169.2 ; v2(237.4,30.52) 237.34,30.52 237.14,30.32 237.14,30.22 237.29,30.07 RP12.1 ; Q14.6 186.71,69.85 186.53,69.67 186.53,65.81 186.39,65.67 186.39,63.19 185.4,62.19 177.76,62.19 176.86,63.08 Q15.6 176.65,61 176.48,60.82 173.41,60.82 172.42,61.81 v1(171.03,61.81) 169.48,61.81 168.9,61.23 168.46,61.23 168.28,61.4 v2(168.28,62.09) 168.38,62.19 168.38,64.89 165.34,67.93 162.03,67.93 159.52,65.42 159.52,59 155.71,55.18 135.72,55.18 128.99,61.91 121.7,61.91 120.38,63.23 120.38,63.87 119.85,64.4 118.37,64.4 118.22,64.25 118.22,63.97 118.31,63.88 Q17.6
  IN3 w0.114: v2(168.28,62.09) 168.28,61.07 167.37,60.16 167.37,53.19 173.82,46.73 174.22,46.73 176.18,44.78 178.35,44.78 179.6,43.53 182.08,43.53 189.9,35.71 194.79,35.71 197.22,33.27 197.62,32.88 200.22,32.88 201.02,32.08 206.43,32.08 207.18,32.83 208.71,32.83 210.34,31.2 213.47,31.2 214.23,30.44 218.19,30.44 219.17,31.42 221.75,31.42 222.49,32.16 226.02,32.16 226.35,32.16 226.79,32.6 226.87,32.6 226.94,32.67 229.99,32.67 230.07,32.59 231.63,32.59 231.78,32.44 231.78,32.42 232.24,31.96 236.58,31.96 236.95,31.59 236.95,31.03 237.06,30.91 237.4,30.58 v2(237.4,30.52) 237.59,30.71 240.69,30.71 245.52,35.55 260.24,35.55 260.94,34.85 264.3,34.85 265.37,35.93 265.37,36.75 v2(265.51,36.89)
  BOTTOM w0.102: U23.95 236.42,32.29 236.74,31.96 236.74,31.18 v2(237.4,30.52)
SMBDATA: length 25.6
  IN3 w0.114: v2(170.65,86.75) 170.37,87.03 168.13,87.03 166.71,85.6 165,85.6 163.19,87.41 162.49,87.41 v2(162.09,87.01)
  BOTTOM w0.076: U14.AH1 161.03,86.28 161.33,86.57 161.63,86.57
  BOTTOM w0.102: v2(162.09,87.01) 161.65,86.57 161.63,86.57 ; v2(170.65,86.75) 170.65,85.2 171.86,83.98 174.96,83.98 175.49,84.51 175.49,87.9 174.88,88.51 RP20.1 174.55,88.26 175,87.8 Q34.6
SMC: length 3.6
  TOP w0.102: v1(27.47,11.39) 27.7,11.16 CN18.5
  BOTTOM w0.254: CN18.5 26.96,10.71 PR203.1
SMC_EXTSMI_N: length 120.6
  TOP w0.102: D5.2 215.37,35.62 214.28,34.53 v2(213.7,34.53)
  IN3 w0.114: v2(213.7,34.53) 213.57,34.4 210.82,34.4 209.67,35.55 200.98,35.55 200.6,35.93 198.25,35.93 194.49,39.69 192.5,39.69 192.44,39.69 190.83,41.31 190.59,41.31 186.44,45.45 186.44,45.74 185.04,47.15 183,47.15 179.68,47.15 179.46,47.36 178.54,48.28 176.44,48.28 170.59,54.13 170.59,57.19 172.34,58.93 172.34,61.1 172.08,61.36 171.41,62.03 171.41,69.35 171.46,69.39 174.31,72.24 177.06,72.24 177.47,72.66 177.47,77.21 177.25,77.43 177.25,79.11 176.97,79.39 176.97,82.66 176.53,83.1 176.53,89.02 176.68,89.18 176.68,92.34 176.99,92.65 176.99,94 175.81,95.19 174.71,95.19 174.25,95.65 v2(171.34,95.65)
  BOTTOM w0.076: U14.V1 160.27,91.52 160.56,91.81 161.78,91.81 162.05,92.08 162.05,92.29 163.19,93.43 163.4,93.43 163.43,93.46
  BOTTOM w0.102: 163.43,93.46 165.2,93.46 R318.1 165.72,93.97 165.93,93.75 165.93,93.73 166.26,93.41 167.42,93.41 167.8,93.79 169.18,93.79 169.53,93.79 169.96,94.22 169.96,95.16 170.2,95.4 171.09,95.4 v2(171.34,95.65)
SMD: length 4
  BOTTOM w0.102: v1(24.33,12.68) PR202.1
  BOTTOM w0.254: PR202.1 25.51,10.15 CN18.6
SNR_HUB_EN: length 16.6
  TOP w0.102: v2(159.14,86.65) 159.72,86.65 160.25,86.12 161.99,86.12 162.6,85.51 163.67,85.51 164.15,85.99 166.56,85.99 166.91,86.35 168.03,86.35 168.64,85.74 169.09,85.74 170.43,84.39 v1(170.85,84.39) 170.88,84.39 170.98,84.29 172.08,84.29 172.55,83.82 172.55,83.54 172.67,83.43 R81.1
  BOTTOM w0.076: U14.AG3 158.84,86.95 v2(159.14,86.65)
SNSR_HUB_RST_ACCEL_DRDY_N: length 7.4
  BOTTOM w0.076: U14.AK4 158.48,85.86 158.96,85.86 159,85.82 159.79,85.82 159.95,85.98 160.97,85.98 161.21,86.22 161.63,86.22
  BOTTOM w0.102: R336.1 163.3,88.38 162.49,87.57 162.49,86.81 161.9,86.22 161.63,86.22
SP_PLLVDD:
  vias: v1(183.6,93) v2(185.53,93.48) v2(185.5,92.65)
SPI_CLK: length 3
  BOTTOM w0.102: U21.6 193.68,40.25 v2(193.1,40.83) 192.92,41.01 R456.2
SPI_CS#: length 3.1
  BOTTOM w0.102: R452.2 204.96,42.41 v1(204.2,42.41) 203.83,42.79 U21.1
SPI_SI: length 4.6
  BOTTOM w0.102: v1(195.28,37.63) 194.84,38.08 U21.5 193.91,38.98 193.34,39.55 193.09,39.55 192.64,39.99 R460.2
SPI_SO: length 3.3
  BOTTOM w0.102: R458.2 205.09,40.25 v1(204.2,41.13) 203.82,41.52 U21.2
SRN: length 3.7
  TOP w0.254: PU3.12 48.23,30.45 48.8,31.02 v1(50.1,31.02) 50.4,31.33 PR63.2
SRP: length 3.8
  TOP w0.102: PR62.1 48.98,32.22 v1(48.12,32.22)
  TOP w0.254: PU3.13 47.73,30.72 49.03,32.02 PR62.1
SRTC_RST#: length 9.8
  BOTTOM w0.076: 156.57,77.96 156.48,78.06 156.48,80.08 U14.AV6
  BOTTOM w0.102: R405.1 160.69,74.26 160.51,74.44 C450.1 160.16,74.91 159.98,75.09 159.98,76.06 159.44,76.59 158.02,76.59 156.65,77.96 156.57,77.96
STRAP0: length 6.3
  BOTTOM w0.102: U13.D1 180.26,85.6 179.95,85.91 178.57,85.91 178.41,85.74 R355.2 R356.1
STRAP1: length 7.2
  BOTTOM w0.102: R362.1 R361.2 178.41,84.64 178.51,84.75 181.21,84.75 181.67,85.2 182.81,85.2 183.21,85.6 U13.D2
STRAP2: length 11.1
  BOTTOM w0.102: R342.2 R343.1 177.03,87.89 176.64,88.28 176.64,89.65 v1(176.89,89.9)
  BOTTOM w0.114: R342.2 178.94,87.09 181.86,87.09 182.05,86.9 184.65,86.9 184.67,86.87 185.06,86.49 U13.E4
STRAP3: length 8.2
  BOTTOM w0.102: R349.1 R348.2 178.41,86.8 178.48,86.88 180.07,86.88 180.96,85.99 183.22,85.99 183.34,86.11 183.96,86.11 U13.E3
STRAP4: length 6.4
  BOTTOM w0.102: R364.2 180.25,83.17 181.49,84.42 182.89,84.42 183.07,84.59 183.07,85.1 183.22,85.25 183.78,85.25 184.12,85.6 U13.D3
SUB_GND: length 15.2
  TOP w0.102: C394.1 296.71,24.07 v1(297.32,24.07)
  TOP w0.356: v2(288.43,26.58) U12.7
  TOP w0.508: v2(295.89,27.16) 295.89,27.86 295.77,27.98 R250.2 ; v2(295.33,25.26) 295.45,25.37 295.45,25.42 295.92,25.89 R273.1 296.16,25.75 C394.1 ; C343.1 286.52,29.3 v2(286.62,29.4) 287.69,29.4 288.27,28.82 C351.2 C350.1
  IN2 w0.508: v2(295.33,25.26) 293.66,26.94 v2(291.91,26.94)
  vias: v2(291.24,26.96)
SUB_MUTE#: length 23.4
  TOP w0.102: U12.1 292.71,25.93 292.19,25.42 R277.2 v2(292.84,24.67) v1(293.61,24.67)
  BOTTOM w0.102: D19.2 290.45,37.51 290.45,36.57 290.18,36.3 288.45,36.3 288.22,36.53 288.22,36.68 287.95,36.96 287.58,36.96 287.28,36.66 287.28,35.75 287.76,35.27 287.76,32.85 288.63,31.99 290.08,31.99 291.17,30.9 291.17,28.51 292.84,26.83 v2(292.84,24.67)
SUB_OUT: length 32.2
  TOP w0.254: U10.37 309.06,38.47 309.23,38.64 310.68,38.64 311.84,39.81 v2(312.91,39.81) ; v2(299.55,26.22) 299.27,26.5 297.65,26.5 297.35,26.8 C358.1
  IN3 w0.254: v2(299.55,26.22) 299.91,25.87 308.14,25.87 309.51,27.24 309.51,27.65 310.73,28.87 310.73,29.83 311.95,31.05 311.95,32.42 312.4,32.88 312.4,39.31 v2(312.91,39.81)
SUB_OUT+: length 16.9
  BOTTOM w0.787: CN10.1 305.73,32.33
  BOTTOM w1.016: 294.72,27.55 294.72,27.06 295.54,26.25 296.65,26.25 297.51,27.1 298.75,27.1 v1(299.31,27.66) 299.31,27.86 301.54,30.09 301.54,31.38 301.58,31.42 301.58,31.43 302.17,32.02 303.16,32.02 303.36,31.81 304.83,31.81 305.35,32.33 305.73,32.33
SUB_OUT+_L:
  vias: v1(289.8,29.2)
SUB_OUT+_MOS:
  vias: v1(292.34,32.73) v2(288.83,32.7) v2(289.47,32.7) v2(292.26,28.97) v2(292.9,28.99)
SUB_OUT-: length 15.8
  BOTTOM w0.787: CN10.2 305.6,33.58
  BOTTOM w1.016: 294.75,30.34 294.75,29.98 295.31,29.42 298.86,29.42 299.73,30.29 v1(299.73,31.33) 299.73,32.12 300.54,32.93 301.08,32.93 301.72,33.58 305.6,33.58
SUB_OUT-_L:
  vias: v1(289.77,24.57)
SUB_OUT-_MOS: length 8.1
  TOP w0.102: v2(293.02,30.92) 293.1,31 v1(293.1,31.63)
  IN1 w1.016: 290.56,25.01 291.47,25.01 292.92,26.45 292.92,27.55 293.96,28.59 293.96,30.01 293.68,30.29
  vias: v2(287.23,24.75) v2(287.23,24.12) v2(292.39,30.92)
SUB_PD#_EC: length 81.1
  TOP w0.102: v2(286.75,36.46) 285.2,34.91 v1(285.2,34.4) 285.2,33.84 285.07,33.72 285.07,32.9 284.92,32.75 Q24.2
  IN1 w0.089: v2(286.75,36.46) 285.73,35.44 285.73,33.75 284.72,32.74 284.72,29.52 283.15,27.95 264.9,27.95 263.36,29.5 261.58,29.5 260.13,28.05 258.53,28.05 258.05,28.54 252.2,28.54 251.42,29.32 241.39,29.32 239.77,27.7 235.26,27.7 233.39,25.82 227.33,25.82 v2(226.91,26.25)
  BOTTOM w0.102: v2(286.75,36.46) 286.75,36.69 287.64,37.58 D19.1 ; U23.118 225.49,29.26 225.76,28.99 225.76,27.32 226.8,26.28 226.88,26.28 v2(226.91,26.25)
SUS_ENABLE: length 24.3
  TOP w0.203: 204.95,22.23 PU6.9
  TOP w0.254: v2(200.74,29.3) 200.74,31.43 199.53,32.65 199.53,35.85 v1(196.07,39.31) 195.6,39.78 PR207.2 ; 204.95,22.23 205.22,22.23 v2(205.32,22.13)
  BOTTOM w0.254: v2(205.32,22.13) 205.32,23.91 203.03,26.2 201.66,26.2 200.74,27.11 v2(200.74,29.3)
SUS_ON: length 272.7
  TOP w0.102: v2(231.5,19.62) 230.82,20.31 230.82,23.33 231.25,23.76 233.44,23.76 233.79,24.11 233.79,27.04 234.17,27.42 R254.1 R255.2 235.19,28.38 v2(234.73,27.93) ; v2(171.64,31.84) 171.22,32.25 PR82.2 ; PU6.1 202.13,20.07 201.86,19.8 201.71,19.8 v2(201.43,19.52) 201.85,19.11 207.57,19.11 208.31,19.85 208.31,21.42 205.09,24.65 205.09,28.41 205.42,28.74 205.42,29.37 204.82,29.97 204.82,31.11 203.78,32.14 203.62,32.14 201.69,32.14 200.74,33.09 200.74,37.64 195.99,42.39 v1(195.99,44.44) 195.99,45.96 194.39,47.56 194.39,52.16 v2(194.83,52.59)
  IN1 w0.089: v2(231.5,19.62) 229.16,17.28 203.66,17.28 201.67,19.27 201.67,19.29 v2(201.43,19.52) 199.47,17.56 186.77,17.56 181.54,22.8 181.54,28.51 177.89,32.16 171.89,32.16 171.64,31.91 v2(171.64,31.84)
  IN2 w0.114: v2(213.29,122.62) 213.29,118.5 211.72,116.93 211.72,115.35 212.42,114.65 218.39,114.65 222.97,110.07 222.97,105.8 223.36,105.42 223.36,99.8 223.51,99.65 223.51,99.63 223.63,99.51 223.63,92.38 223.8,92.21 223.8,84.68 223.25,84.13 223.25,82.43 222.59,81.77 222.59,73.61 220.52,71.54 211.79,71.54 202.47,80.86 198.81,80.86 193.89,75.93 190.45,75.93 188.77,74.26 188.19,74.26 185.33,71.4 185.33,69.03 185.76,68.6 185.76,60.13 188.25,57.64 190.48,57.64 194.83,53.3 v2(194.83,52.59)
  BOTTOM w0.102: v2(234.73,27.93) 234.73,28.86 234.15,29.44 234.15,31.05 233.66,31.53 232.9,31.53 232.69,31.33 U23.100 ; v2(213.29,122.62) 212.48,123.43 211.77,123.43 211.54,123.2 PR134.2
SUSACK#_R: length 24.5
  TOP w0.102: R109.2 173.73,76.37 173.16,75.81 v1(172.91,75.81) 172.4,75.81 172.14,76.06 172.14,78.83 v2(171.81,79.16)
  IN3 w0.114: v2(171.81,79.16) 171.39,79.58 171.39,80.33 172,80.94 172,81.9 172.34,82.24 172.34,83.34 171.9,83.78 169.52,83.78 168.71,84.59 164.37,84.59 v2(162.85,86.12)
  BOTTOM w0.076: 161.63,86.02 161.24,86.02 161.04,85.82 160.02,85.82 159.73,85.53 U14.AK2
  BOTTOM w0.102: 161.63,86.02 162.31,86.02 162.42,86.12 v2(162.85,86.12)
SYS_PWR_SW#: length 46.3
  TOP w0.102: v2(210.65,21.88) v1(210.65,20.89) 210.65,19.47 209.68,18.5 200.54,18.5 200.42,18.38 196.41,18.38 195.35,19.43 195.35,21.57 194.96,21.96 193.91,21.96 193.52,22.35 R279.1 C398.1 192.27,22.12 192.68,21.72 193.01,21.72 193.81,20.92 D7.2
  BOTTOM w0.102: v2(210.65,21.88) 221.09,21.88 222.42,23.21 222.42,25.55 222.82,25.94 222.82,28.61 222.69,28.74 U23.125
SYS_PWROK: length 117.3
  TOP w0.102: v2(170.52,59.78) 171.94,59.78 172.71,59.02 180.54,59.02 182.05,57.51 191.79,57.51 192.18,57.9 193.1,57.9 195.54,55.46 195.54,52.06 194.88,51.4 194.88,47.76 199.85,42.79 225.35,42.79 226.83,44.26 228.95,44.26 229.21,43.99 v1(229.53,43.99) 230.47,43.99 v2(230.5,43.97)
  IN3 w0.114: v2(170.52,59.78) 170.52,60.69 168.77,62.44 168.77,70.34 174.84,76.41 174.84,81.72 174.54,82.01 174.54,85.2 173.93,85.81 173.93,89.15 174.7,89.92 174.7,92.27 173.92,93.05 171.69,93.05 171.31,92.67 v2(171.31,92.57)
  BOTTOM w0.102: U23.57 231.09,44.56 v2(230.5,43.97) ; R324.1 171.26,91.49 171.26,92.42 171.31,92.47 v2(171.31,92.57)
SYS_PWROK_R: length 15
  BOTTOM w0.076: 162.11,88.35 162.07,88.31 161.46,88.31 161.2,88.05 161.2,87.82 160.8,87.42 160.43,87.42 160.33,87.32 160.02,87.32 159.73,87.02 U14.AG2
  BOTTOM w0.102: v1(170.59,92.44) 170.52,92.37 170.52,91.43 ; 162.11,88.35 162.17,88.35 162.6,88.78 162.67,88.78 163.68,89.8 164.96,89.8 165.63,89.12 166.99,89.12 167.32,89.44 167.32,89.7 167.76,90.14 168.78,90.14 169.03,90.39 R327.1 169.37,90.79 170,91.43 170.52,91.43 ; 170.52,91.43 R324.2
SYS_RESET#: length 8
  BOTTOM w0.076: 163.43,89.87 162.66,89.1 161.67,89.1 161.44,88.87 161.03,88.87 160.8,89.1 160.43,89.1 160.31,88.98 159.35,88.98 159.1,89.23 U14.AC3
  BOTTOM w0.102: 163.43,89.87 163.56,90 165.07,90 165.55,89.52 R331.1
SYS_SHDN#: length 13.2
  TOP w0.102: Q13.1 118.25,70.12 118.09,69.96 118.09,69.2 117.58,68.69 116.31,68.69 115.68,69.33 115.68,70.22 115.04,70.85 113.52,70.85 113.43,70.94 U3.4 113.43,73.12 113.3,73.26 R115.2 111.62,73.13 111.62,72.25 v1(111.77,72.1)
T_WLAN: length 225.5
  TOP w0.102: v2(68.56,39.2) 68.59,39.2 69.63,38.16 72.55,38.16 76.57,34.15 78.47,34.15 79.5,35.18 86.86,35.18 87.79,36.1 92.29,36.1 94.78,38.59 97.67,38.59 99.12,37.15 103.21,37.15 104.66,38.59 108.64,38.59 110.4,36.84 116.52,36.84 117.25,37.58 117.25,38.67 120.23,41.64 120.23,49.47 121.24,50.48 160.97,50.48 167.78,57.29 167.78,59.47 169.48,61.17 172.27,61.17 173.41,60.03 181.62,60.03 183.02,58.63 190.53,58.63 190.66,58.76 193.45,58.76 196.38,55.84 196.38,50.01 195.82,49.45 195.82,48.01 200.2,43.62 224.77,43.62 v1(225.09,43.94) 226.25,45.1 230.56,45.1 231.91,43.75 232.07,43.75 236.41,43.75 v2(238.59,41.57) ; v2(58.52,43.65) R483.1 57.55,44.36 RT1.2
  IN3 w0.114: v2(68.56,39.2) 67.52,39.2 62.54,44.18 59.05,44.18 v2(58.52,43.65)
  BOTTOM w0.102: v2(238.59,41.57) 237.12,41.57 236.64,41.09 U23.73
TD_IREF: length 7.3
  BOTTOM w0.076: U14.B12 152.67,103.24
  BOTTOM w0.102: R289.1 155.86,105.14 155.35,104.63 153.78,104.63 153.6,104.46 152.79,104.46 v1(152.36,104.02) 152.67,103.71 152.67,103.24
TESTLOW_0: length 7.3
  BOTTOM w0.076: v1(136.51,106.34) 136.74,106.34 137.45,105.62 RP13.3 137.45,104.86 137.68,104.63 137.68,103.28 138.41,102.54 138.61,102.54 138.8,102.36 138.8,101.72 138.89,101.46 138.89,101.36 138.84,101.24 138.83,101.2 138.83,101.02 138.87,100.86 138.97,100.71 U14.C35
TESTLOW_1: length 9.3
  BOTTOM w0.076: U14.C34 139.58,100.56 139.41,100.73 139.23,100.73 139.02,100.94 139,101.04 139,101.17 139.02,101.23 139.03,101.24 139.05,101.33 139.05,101.49 138.97,101.72 138.97,102.42 138.68,102.71 138.48,102.71 137.88,103.31 137.88,104.64 138.1,104.86 RP13.1 138.1,105.62 139.3,106.82 139.3,107.58 v1(139.12,107.76)
