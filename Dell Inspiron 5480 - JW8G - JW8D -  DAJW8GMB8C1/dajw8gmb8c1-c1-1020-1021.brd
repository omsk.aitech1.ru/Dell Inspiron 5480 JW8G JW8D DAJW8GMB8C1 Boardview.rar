# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_TXN1_RL: length 4.4
  BOTTOM w0.114: CN11.14 278,31.88 277.88,31.76 277.88,31.39 278.14,31.13 278.14,30.77 v1(278.6,30.31) 278.24,30.31 278.04,30.11 278.04,29.82 278.26,29.6 EL13.4
EDP_TXP0: length 260.5
  TOP w0.114: C283.2 257.71,38.73 257.49,38.95 257.49,39.29 257.74,39.53 v2(258.15,39.53)
  BOTTOM w0.076: U14.B46 132.51,100.76 132.62,100.65 132.62,100.56 132.47,100.4 132.15,100.4 132.06,100.49 132.06,100.56 131.91,100.71 131.91,100.82 132.14,101.05 132.32,101.05 132.39,101.13 132.39,101.28 132.22,101.46 132.22,102.14 132.16,102.2
  BOTTOM w0.114: 132.16,102.2 132.16,103.89 128.78,107.28 119.8,107.28 116.59,104.08 112.44,104.08 107.41,99.05 107.41,94.13 106.69,93.41 106.69,88.86 106.05,88.23 106.05,76.64 111.95,70.75 114.06,70.75 122.87,61.94 133.64,61.94 145.43,50.15 175.8,50.15 176.5,49.45 181.21,49.45 182.25,48.41 182.25,46.57 183.5,45.33 183.5,42.18 184.69,40.99 184.69,36.47 185.72,35.43 v1(186.48,35.43) 186.48,34.67 189.01,32.14 191.91,32.14 194.19,29.86 194.19,26.05 196.83,23.41 196.83,22.57 197.29,22.11 198.16,22.11 201.92,18.35 234.27,18.35 241.38,25.46 244.08,25.46 245.78,27.16 250.55,27.16 252.33,28.95 252.33,32.86 254.52,35.04 256.52,35.04 259.24,37.76 259.24,39.73 258.7,40.27 257.84,40.27 257.65,40.07 257.65,39.63 257.74,39.53 v2(258.15,39.53)
EDP_TXP0_C: length 3.1
  TOP w0.114: U25.38 256.99,35.77 256.87,35.9 256.87,36.02 257.67,36.81 257.67,37.57 C283.1
EDP_TXP0_R: length 6.4
  TOP w0.114: U25.23 256.99,27.84 256.87,27.71 256.87,27.6 256.99,27.49 258.24,27.49 259.19,28.43 259.49,28.43 v1(259.95,28.89) 259.95,28.69 260.38,28.26 260.79,28.26 261.09,28.55 C529.2
EDP_TXP0_RC: length 18.8
  TOP w0.114: v2(263.39,28.71) 263.06,28.38 262.25,28.38 C529.1
  IN3 w0.102: v2(274.63,25.6) 275.06,25.6 275.16,25.5 275.16,24.77 275.06,24.67 274.1,24.67 270.37,28.41 263.69,28.41 v2(263.39,28.71)
  BOTTOM w0.114: v2(274.63,25.6) 274.77,25.6 275.32,26.15 275.32,26.49 275.05,26.76 EL14.2
EDP_TXP0_RL: length 4.5
  BOTTOM w0.114: EL14.1 275.05,29.6 275.25,29.8 275.25,30.06 274.99,30.31 ; 274.99,30.31 275.12,30.31 275.34,30.54 275.34,30.85 276.12,31.63 276.12,31.75 276,31.88 CN11.10 ; 274.99,30.31 v1(274.79,30.31)
EDP_TXP1: length 250.1
  TOP w0.114: v2(255.23,39.56) 254.98,39.56 254.8,39.37 254.8,39.02 255.06,38.76 C281.2
  BOTTOM w0.076: 130.53,104.43 130.67,104.43 131.47,103.64 131.47,101.68 131.38,101.59 131.38,101.34 131.45,101.26 131.52,101.26 131.69,101.42 132,101.42 132.06,101.36 132.06,101.21 131.94,101.09 U14.B47
  BOTTOM w0.114: 130.53,104.43 129.7,105.26 129.7,105.26 129.48,105.48 128.45,106.51 120.18,106.51 116.98,103.31 112.73,103.31 108.16,98.74 108.16,93.82 107.45,93.11 107.45,88.43 106.82,87.79 106.82,77.58 112.81,71.59 114.46,71.59 120.79,65.26 122.07,65.26 124.61,62.72 134.2,62.72 146.02,50.9 176.3,50.9 177,50.2 181.52,50.2 183.04,48.68 183.04,46.87 184.39,45.53 184.39,42.35 185.43,41.3 185.43,37.65 190.18,32.9 192.41,32.9 195.79,29.53 195.79,28.22 v1(196.28,27.73) 195.79,27.24 195.79,26.43 197.67,24.55 197.67,23.58 198.13,23.13 198.94,23.13 201.33,20.74 202.22,20.74 203.86,19.1 233.8,19.1 241.05,26.35 243.77,26.35 245.34,27.93 250.07,27.93 251.39,29.25 251.39,34.46 256.35,39.41 256.35,39.76 256.04,40.07 255.16,40.07 254.94,39.85 254.94,39.64 255.01,39.56 v2(255.23,39.56)
EDP_TXP1_C: length 3
  TOP w0.114: C281.1 254.92,37.59 254.92,36.64 255.37,36.19 255.37,35.9 255.5,35.77 U25.41
EDP_TXP1_R: length 6.5
  TOP w0.114: C531.2 258.93,26.32 258.76,26.15 256.47,26.15 256.27,26.35 v1(256.27,26.76) 256.24,26.76 255.76,26.28 255.63,26.28 255.37,26.54 255.37,27.71 255.5,27.84 U25.20
EDP_TXP1_RC: length 23.6
  TOP w0.114: C531.1 260.09,26.15 260.74,26.15 260.96,26.38 266.6,26.38 v2(266.86,26.64)
  IN3 w0.102: v2(277.17,25.6) 277.6,25.6 277.7,25.5 277.7,24.44 277.2,23.94 273.44,23.94 271.03,26.35 267.15,26.35 v2(266.86,26.64)
  BOTTOM w0.114: EL13.2 277.46,26.76 277.81,26.41 277.81,26 277.41,25.6 v2(277.17,25.6)
EDP_TXP1_RL: length 4.4
  BOTTOM w0.114: EL13.1 277.46,29.52 277.78,29.84 277.78,30.11 277.58,30.31 v1(277.33,30.31) 277.88,30.87 277.88,31.02 277.62,31.28 277.62,31.76 277.5,31.88 CN11.13
EN_LCDVCC: length 6.8
  TOP w0.102: U22.3 276.75,40.29 R464.1 277.23,40.25 277.6,40.63 v2(277.6,41.52)
  BOTTOM w0.102: D18.3 276.33,42.68 277.5,41.52 v2(277.6,41.52) 277.94,41.85 v1(277.94,42.3)
ENTRIP1: length 9.4
  TOP w0.152: PR85.2 138.09,31.01 138.85,31.77 PQ14.3
  TOP w0.254: PR85.2 137.17,31.82 136.94,32.05 v1(136.68,32.05) 136.17,32.05 135.37,31.26 134.38,31.26 133.84,30.72 132.88,30.72 132.71,30.55 PU4.1
ENTRIP2: length 5.3
  TOP w0.254: PU4.6 130.21,30.44 v1(129.06,31.58) 128.89,31.75 PR79.1 126.9,31.75 126.25,31.1 PQ13.3
EQ: length 6.5
  TOP w0.102: U2.17 313.26,83.26 314.05,84.06 R79.2 R76.1 315.14,84.62 315.7,84.62 315.93,84.85 315.93,85.53 v1(316.54,86.14)
EXT_MIC_1: length 17
  TOP w0.254: v2(316.67,26.71) 316.67,27.29 316.41,27.55 C360.1 316.06,28.48 v1(315.93,28.61) 315.11,28.61 C353.2 314.86,28.52 313.88,28.52 R268.2 313.8,28.94 313.93,29.07 L16.2
  IN3 w0.254: v2(316.67,26.71) 316.72,26.66 326.56,26.66 CN12.4
EXT_MIC_2: length 3.6
  TOP w0.254: v1(315.81,34.23) 315.36,33.78 R227.2 314.81,33.77 C323.1 C326.2
EXT_MIC_L1: length 2.6
  TOP w0.254: C326.1 311.44,33.23 310.57,33.23 310.53,33.28 U10.28
EXT_MIC_R: length 12.8
  TOP w0.254: L16.1 313.93,31.63 314.31,32.02 314.31,32.65 314.65,33 R227.1 315.02,32.79 v2(315.02,32.19) ; v2(310.78,27.01) 310.42,26.66 R270.2 310.13,27.78 R267.1
  IN3 w0.254: v2(315.02,32.19) 310.78,27.95 v2(310.78,27.01)
  BOTTOM w0.254: v1(310.09,26.83) 310.27,27.01 v2(310.78,27.01)
EXT_MIC_R1: length 2.5
  TOP w0.254: U10.29 310.81,33.78 311.08,34.05 v1(311.08,34.02) 311.11,34.05 311.89,34.05 C323.2
FAN1_PWM: length 171.6
  TOP w0.102: v1(102.87,42.8) 102.42,42.35 v2(102.42,42.12)
  IN1 w0.089: v2(215.37,22.64) 214.89,22.16 212.8,22.16 212.32,22.64 204.61,22.64 203.88,23.37 201.74,23.37 200.65,24.46 193.57,24.46 191.5,26.53 191.5,27.58 190.82,28.26 189.75,28.26 182.18,35.82 140.57,35.82 139.77,36.61 116.65,36.61 114.41,38.85 112.38,38.85 109.1,42.12 v2(102.42,42.12)
  BOTTOM w0.102: v2(215.37,22.64) 215.78,23.05 215.78,28.61 216.15,28.98 216.74,28.98 217.05,29.3 218.45,29.3 221.47,32.32 221.47,33.8 221.1,34.17 221.1,38.11 222.79,39.8 222.79,41.59 221.7,42.69 U23.28 ; FAN1.2 102.15,54.08 102.57,54.49 106.15,54.49 106.61,54.04 106.61,50.41 107.53,49.49 107.53,45.05 106.74,44.26 104.84,44.26 102.7,42.12 v2(102.42,42.12)
FAN1_TACH: length 180.8
  TOP w0.102: v2(102.42,41.46) 102.18,41.7 v1(101.68,41.7)
  IN1 w0.089: v2(102.42,41.46) 109.03,41.46 112.01,38.48 114.42,38.48 116.57,36.33 139.45,36.33 140.22,35.57 182.08,35.57 189.09,28.56 189.09,27.21 189.49,26.81 190.76,26.81 193.3,24.27 200.58,24.27 201.66,23.18 203.7,23.18 205.16,21.73 210.02,21.73 210.35,21.4 210.96,21.4 211.44,21.88 215.32,21.88 v2(216.04,22.59)
  BOTTOM w0.102: U23.47 227.09,45.06 226.54,44.5 226.54,43.44 227.09,42.89 227.09,42.87 227.9,42.06 227.9,39.66 227.47,39.23 227.47,38.54 228.41,37.6 228.41,37.21 228.01,36.82 225.04,36.82 224.52,36.29 224.52,35.83 224.2,35.52 223.93,35.52 222.18,33.78 222.18,32.03 220.38,30.22 220.38,29.15 220.01,28.79 217.04,28.79 216.84,28.59 216.84,23.4 v2(216.04,22.59) ; FAN1.4 101.79,56.58 102.09,56.27 102.56,56.27 R425.1 104.14,54.7 105.61,54.7 106.07,54.7 106.24,54.7 106.82,54.12 106.82,50.49 107.73,49.57 107.73,44.94 106.84,44.06 105.01,44.06 v2(102.42,41.46)
FAN2_PWM: length 39.5
  TOP w0.102: v2(222.35,40.66) 223.38,41.69 235.75,41.69 v1(236.08,41.37) 236.82,40.63 239.45,40.63 241.56,42.74 241.56,43.95 241.83,44.22 241.83,44.44 241.93,44.54 v2(242.02,44.54)
  BOTTOM w0.102: v2(242.02,44.54) 242.45,44.97 242.45,45.96 242.58,46.09 242.58,52.73 241.8,53.51 240.81,53.51 240,54.31 FAN2.2 ; U23.25 221.53,41.49 v2(222.35,40.66)
FAN2_TACH: length 24.2
  BOTTOM w0.102: R422.1 235.57,58.13 236.14,57.55 237.26,57.55 237.5,57.31 FAN2.4 237.5,54.59 237.35,54.44 237.35,53.29 238.33,52.3 v1(238.33,49.72) 238.33,49.11 237.84,48.62 232.43,48.62 230.79,46.98 227.73,46.98 227.49,46.74 U23.48
FB_CAL_PD_VDDQ: length 7.8
  TOP w0.254: v2(205.61,84.49) 206.22,83.87 R80.2
  IN3 w0.254: v2(205.61,84.49) 205.48,84.62 203.03,84.62 202.32,83.9 201.74,83.9 200.47,85.18 200.47,85.2 v2(200.44,85.23)
  BOTTOM w0.305: v2(200.44,85.23) 200.47,85.2 200.47,85.11 200,85.58 U13.D22
FB_CAL_PU_GND: length 5.8
  TOP w0.254: R73.2 206.44,85.03 205.9,85.03 205.73,85.2 203.55,85.2 v1(203.49,85.14) 203.43,85.2 v2(202.1,85.2)
  BOTTOM w0.102: v2(202.1,85.2) U13.C24
FB_CAL_TERM_GND: length 7.2
  IN3 w0.254: v2(202.1,84.4) 202.13,84.43 202.13,84.44 202.74,85.05 206.01,85.05 206.37,84.68 v2(206.37,84.49)
  BOTTOM w0.254: R359.2 207.24,85.08 206.74,85.08 206.37,84.71 v2(206.37,84.49)
  BOTTOM w0.381: U13.B25 202.5,84.01 202.11,84.4 202.1,84.4 202.11,84.4 v2(202.1,84.4)
FB_CLAMP_MON: length 7.8
  TOP w0.102: v2(184.72,86.04) 184.51,85.83 R71.1
  BOTTOM w0.102: v2(184.72,86.04) 184.79,85.97 186.98,85.97 187.18,85.76 187.18,85.43 186.8,85.05 U13.C6
FB_CLAMP_TGL_R_REQ#: length 5.6
  TOP w0.102: R181.2 217.67,38.38 v2(218.19,37.86) 218.58,37.86 219.95,39.23 v1(219.95,39.61)
  BOTTOM w0.102: v2(218.19,37.86) 218.62,38.29 U23.17
FB_CLAMP_TGL_REQ#: length 121
  TOP w0.102: v2(174.84,113.6) 173.85,113.6 173.69,113.75 173.69,115.18 173.56,115.31 R8.1 ; v1(216.64,39.74) 216.77,39.61 216.77,38.84 R181.1 216.89,38.53 v2(217.56,37.86)
  IN2 w0.114: v2(189.92,49.57) 189.29,50.2 189.29,54.78 184.01,60.06 184.01,71.99 180.09,75.91 180.09,77.54 179.35,78.27 179.35,80.15 179.77,80.57 179.77,81.57 v2(179.61,81.72) 179.69,81.81 179.69,84.29 180.22,84.82 180.22,86.52 181.31,87.61 181.31,88.45 180.99,88.77 180.99,92.95 181.36,93.32 181.36,93.61 180.93,94.04 180.93,94.5 181.14,94.7 181.14,97.94 178.41,100.67 177.85,100.67 174.84,103.68 v2(174.84,113.6)
  IN3 w0.114: v2(189.92,49.57) 189.28,48.92 189.28,46.47 191.2,44.54 192.99,44.54 198.53,39 199.16,38.37 201.45,38.37 201.69,38.12 201.85,37.96 211.34,37.96 211.79,38.42 217,38.42 v2(217.56,37.86)
  BOTTOM w0.102: U13.A4 185.45,82.84 185.45,82.54 185.12,82.21 182.58,82.21 182.41,82.03 179.92,82.03 v2(179.61,81.72)
FB_VREF_PROBE: length 4.3
  TOP w0.102: v2(201.25,85.18) 201.68,85.61 202.73,85.61 202.75,85.59 203.13,85.59 203.16,85.62 203.88,85.62 204.33,86.07 TP9.1
  BOTTOM w0.102: U13.D23 201.25,85.2 v2(201.25,85.18)
FBA_DEBUG: length 7.5
  TOP w0.102: v2(199.6,86.85) 200,86.46 200.62,86.46 200.63,86.44 201.1,86.44 201.11,86.46 201.45,86.46 201.46,86.44 202.27,86.44 202.43,86.6 v2(203.26,86.6) 203.39,86.73 R68.2
  BOTTOM w0.102: v2(199.6,86.85) 200,87.25 U13.F22
FBA_DEBUG1: length 9.4
  TOP w0.102: v2(199.63,89.34) 199.63,89.29 200.01,88.91 200.01,87.56 200.29,87.27 200.63,87.27 200.65,87.29 201.47,87.29 201.48,87.31 202.24,87.31 202.52,87.03 203.51,87.03 203.77,87.29 v1(205.11,87.29) 205.64,87.29 R64.2
  BOTTOM w0.102: v2(199.63,89.34) 200.06,89.77 U13.J22
FIVR_EN_BUF: length 10
  TOP w0.102: R37.1 115.81,97.65 117,97.65 117.73,96.92 117.93,96.92 v1(117.97,96.89) 118,96.92 119.3,96.92 v2(119.67,96.56)
  BOTTOM w0.076: U14.H59 124.06,97.59 123.68,97.22 122.42,97.22 122.37,97.26 121.05,97.26 120.91,97.12 120.23,97.12 v2(119.67,96.56)
G5934CN: length 6.2
  TOP w0.102: PU6.19 201.11,21.43 200.74,21.07 198.86,21.07 198.6,21.33 PC80.2 198.16,21.7 196.78,20.32 v1(196.78,19.95)
G5934CP: length 5.6
  TOP w0.102: PU6.18 200.97,21.83 200.85,21.7 PC80.1 199.38,21.97 199.22,22.13 198.26,22.13 197.9,21.78 197.18,21.78 v1(196.63,21.22)
G5934VIN:
  vias: v1(200.41,20.46)
GFX_SCL: length 24.6
  TOP w0.102: Q14.4 190.04,68.55 190.31,68.82 190.31,70.14 189.22,71.22 R127.1 187.05,71.51 187.13,71.59 187.59,71.59 v2(187.99,72)
  IN1 w0.089: v2(187.99,72) 187.1,72.88 187.1,79.18 189.29,81.37 189.29,84.8 v2(189.7,85.2)
  BOTTOM w0.102: U13.D9 189.28,85.59 189.67,85.2 v2(189.7,85.2)
GFX_SDA: length 19.5
  TOP w0.102: Q14.1 186.03,69.85 186.15,69.97 186.15,70.23 186.04,70.34 185.61,70.34 185.45,70.5 185.45,70.77 R126.1 186.07,71.22 186.47,70.83 v2(186.48,70.83)
  IN1 w0.089: v2(188.83,85.2) 188.83,84.77 188.84,84.76 188.84,81.77 187.76,80.69 187.76,80.25 186.48,78.96 v2(186.48,70.83)
  BOTTOM w0.114: U13.D8 188.44,85.6 188.81,85.24 188.81,85.23 v2(188.83,85.2)
GPIO8: length 11.4
  BOTTOM w0.076: 161.63,81.41 161.37,81.41 161.29,81.33 160.59,81.33 160.51,81.41 159.85,81.41 159.65,81.21 159.6,81.21
  BOTTOM w0.102: 161.63,81.41 162.89,81.41 165.21,83.73 165.79,83.73 165.95,83.88 v1(168.61,83.88) 168.88,84.15 R358.1
  BOTTOM w0.305: U14.AU2 159.6,81.21
GPIO15: length 19.4
  TOP w0.102: v2(157.03,89.21) 157.44,89.62 157.96,89.62 158.36,89.21 159.21,89.21 159.75,89.75 162.67,89.75 163.4,89.02 165.58,89.02 165.7,89.14 166.89,89.14 166.92,89.17 170.82,89.17 171.42,88.57 v1(171.42,88.43) 171.42,88.16 171.15,87.9 171.15,87.47 171.39,87.24 171.73,87.24 172.06,87.57 172.87,87.57 R65.1
  BOTTOM w0.102: v2(157.03,89.21) 156.86,89.03 U14.AD6
GPIO17: length 20.8
  TOP w0.102: v2(159.14,92.64) 159.14,93.21 160.16,94.23 162.75,94.23 163.58,95.07 163.58,96.14 165.5,98.06 168.66,98.06 169.02,97.7 169.02,97.04 169.96,96.1 v1(170.7,96.1) 171.7,96.1 R45.1 171.93,95.43 171.53,95.03 171.34,95.03 v2(171.34,95.03)
  BOTTOM w0.076: U14.T3 158.84,92.94 v2(159.14,92.64)
  BOTTOM w0.102: v2(171.34,95.03) 171.34,95.03 172.18,95.03 172.45,95.3 D8.2
GPIO24: length 17.8
  TOP w0.102: R69.1 172.47,86.47 172.19,86.75 171.59,86.75 170.92,87.41 170.92,87.88 v1(170.15,88.66) 169.87,88.94 165.78,88.94 165.66,88.81 163.06,88.81 162.35,89.52 160.13,89.52 159.6,88.99 157.91,88.99 v2(157.68,89.21)
  BOTTOM w0.102: U14.AD5 157.51,89.03 v2(157.68,89.21)
GPIO28: length 23.1
  TOP w0.102: R66.1 175.76,86.46 v1(175.46,86.16) 175.12,85.81 174.18,85.81 174.02,85.97 172.69,85.97 172.11,86.55 171.43,86.55 170.7,87.29 170.7,87.41 169.95,88.16 169.87,88.16 169.3,88.73 165.87,88.73 165.74,88.61 162.97,88.61 162.26,89.32 160.26,89.32 159.72,88.78 158.54,88.78 158.42,88.66 156.93,88.66 v2(156.38,89.21)
  BOTTOM w0.102: v2(156.38,89.21) 156.21,89.03 U14.AD7
GPIO33: length 5.5
  BOTTOM w0.076: 161.94,94.62 161.79,94.47 161.4,94.47 161.23,94.3 160.57,94.3 160.33,94.06 159.78,94.06 U14.P2
  BOTTOM w0.102: 161.94,94.62 162.19,94.86 162.19,95.27 R310.1
GPIO35: length 4.3
  BOTTOM w0.076: U14.U1 160.24,92.27 160.81,92.84 162.35,92.84 162.73,93.21 162.73,93.54 163.15,93.97 163.49,93.97
  BOTTOM w0.102: R319.1 163.49,93.97
GPIO36: length 11.1
  TOP w0.102: R46.1 164.88,95.36 v1(164.77,95.25) 164.28,94.77 164.28,94.69 162.52,92.92 160.66,92.92 159.57,91.83 158.02,91.83 157.85,91.66 157.44,91.66 v2(157.03,92.07)
  BOTTOM w0.102: U14.V6 156.86,91.89 v2(157.03,92.07)
GPIO37: length 7.5
  BOTTOM w0.076: 163.43,90.18 162.9,89.65 161.78,89.65 161.41,89.27 U14.AC1
  BOTTOM w0.102: 163.43,90.18 163.46,90.21 165.62,90.21 165.77,90.05 166.6,90.05 166.74,90.19 R328.1
GPIO91: length 5.6
  BOTTOM w0.076: 162.33,97.26 161.8,96.74 160.17,96.74 U14.J1
  BOTTOM w0.102: RP16.2 163.04,99.77 162.88,99.61 162.88,97.81 162.33,97.26
GPIO92: length 6.5
  BOTTOM w0.076: 163.1,98.19 163.08,98.17 163.08,98.14 ; U14.K3 158.89,96.05 159.14,96.31 159.68,96.31 159.85,96.47 160.34,96.47 160.44,96.58 161.93,96.58 162.33,96.97
  BOTTOM w0.102: 162.33,96.97 163.08,97.73 163.08,98.14 ; RP16.4 163.44,98.53 163.1,98.19
GPIO93: length 8.7
  BOTTOM w0.076: 161.63,97.69 160.96,97.69 160.49,97.22 159.95,97.22 U14.J2
  BOTTOM w0.102: RP15.4 165.06,100.01 164.8,100.27 163.03,100.27 162.69,99.93 162.69,98.12 162.25,97.69 161.63,97.69
GPIO94: length 8.6
  BOTTOM w0.076: U14.G1 160.55,97.51 160.91,97.88 161.62,97.88 161.63,97.89
  BOTTOM w0.102: v1(165.41,101.46) 165.6,101.27 RP15.2 165.09,100.66 164.91,100.47 162.94,100.47 162.65,100.18 162.65,100.16 162.5,100.01 162.5,98.31 162.07,97.89 161.63,97.89
GPU_GPIO16: length 12.3
  BOTTOM w0.102: TP30.1 175.83,83.3 177.46,83.3 178.06,82.69 181.35,82.69 182.32,83.66 182.84,83.66 183.07,83.88 183.07,84.16 183.29,84.39 183.75,84.39 183.88,84.52 183.88,84.92 184.16,85.2 185.35,85.2 185.75,85.6 U13.D5
GSPI_CS: length 18.9
  TOP w0.102: v2(157.11,93.97) 157.11,93.68 157.34,93.46 159.04,93.46 160.01,94.43 162.6,94.43 163.33,95.16 163.33,96.18 165.41,98.26 168.82,98.26 v1(169.86,97.22) 170.19,96.89 R42.1
  BOTTOM w0.102: v2(157.11,93.97) 156.86,93.71 U14.R6
H_CPU_SVIDALRT#: length 7.9
  BOTTOM w0.076: U14.L62 122.16,95.43 122,95.6 121.38,95.6 121.12,95.35 120.93,95.35 120.71,95.57 120.56,95.57 120.34,95.35 120.07,95.35 119.87,95.54 119.46,95.54 119.39,95.46 119.39,95.27 119.26,95.15 119.05,95.15 118.98,95.21 118.98,95.92 118.88,96.02 118.68,96.02 118.58,95.92 118.58,95.39 118.45,95.26 117.61,95.26 117.51,95.36 117.51,95.46 118.04,96 R312.1
H_CPUPWRGD: length 11.1
  TOP w0.102: v2(122.79,102.37) 122.79,103.08 123.45,103.75 123.45,107.68 123.58,107.81 v1(123.58,109.46) 123.58,110.07 123.05,110.61 R13.2
  BOTTOM w0.076: v2(122.79,102.37) 122.79,102.35 123.09,102.05 123.09,101.57 123.17,101.48 123.17,100.53 U14.C61
H_PROCHOT#: length 9.5
  BOTTOM w0.076: U14.K63 121.39,95.93 119.48,95.93 117.86,97.55 116.16,97.55
  BOTTOM w0.102: 116.16,97.55 114.74,97.55 114.66,97.46 R309.2 114.15,97.14 113.67,97.61 v1(113.67,97.95)
H_PROCHOT_EC: length 6.4
  BOTTOM w0.102: U23.86 236.42,35.89 237.28,35.03 R469.1 239.3,35.03 239.4,34.93 Q43.2 238.49,34.38 v1(237.98,33.87)
H_VR_ENABLE_MCP: length 35.7
  TOP w0.102: R9.2 118.73,113.89 v1(117.89,113.89) ; R9.2 118.85,113.44 118.63,113.21 118.63,111.83 120.25,110.2 120.25,105.22 118.55,103.52 118.55,100.44 119.24,99.76 120,99.76 120.79,98.97 v2(120.79,97.62) ; R9.2 119.02,113.77 119.02,113.76 119.15,113.76 119.38,113.53 119.38,113.41 v2(120,112.79) ; R18.1 125.46,109.37 v2(125.48,109.38)
  BOTTOM w0.076: v2(120.79,97.62) 120.89,97.73 121.22,97.73 121.34,97.85 122.02,97.85 122.15,97.97 123.17,97.97 U14.F60
  BOTTOM w0.102: v2(125.48,109.38) 125.32,109.23 120.46,109.23 120.07,109.61 120.07,112.71 v2(120,112.79) 119.77,113.02 PR165.2
HD_SDIN0: length 2.8
  TOP w0.102: R232.2 300.35,33.13 300.81,33.13 300.97,33.29 301.16,33.29 v1(301.38,33.51) 301.65,33.78 U10.8
HDA_BEEP2: length 5.2
  TOP w0.102: v1(300.74,25.72) 298.99,27.47 298.99,28.49 R258.2 299.31,29.07 R379.1
HDA_BITCLK: length 175.5
  TOP w0.102: v2(298.34,33.5) 298.61,33.76 299.27,33.76 299.36,33.86 299.66,33.86 299.99,34.19 299.99,34.2 C321.1 300.58,34.42 300.72,34.28 301.66,34.28 302.16,34.78 U10.6
  IN3 w0.114: v2(191.53,48.25) 192.48,48.25 199.65,41.08 202.84,41.08 203.31,40.61 221.45,40.61 221.89,40.17 226.14,40.17 226.85,40.88 226.85,40.88 226.97,40.99 229.43,40.99 230.23,41.79 236.94,41.79 238.03,40.7 240.19,40.7 241.23,41.74 249.72,41.74 251.52,43.55 257.62,43.55 259.41,45.34 267.86,45.34 270.49,42.71 270.59,42.71 271.22,42.09 271.22,41.77 272.41,40.58 276.1,40.58 276.16,40.52 276.85,40.52 277.91,39.46 280.68,39.46 281.35,38.78 283.13,38.78 285.92,36 288.33,36 288.39,35.93 290.71,35.93 291.48,35.17 296.68,35.17 v2(298.34,33.5)
  BOTTOM w0.102: v2(191.53,48.25) 191.46,48.25 190.96,47.75 190.63,47.75 190.31,48.07 189.52,48.07 188.32,49.26 188.32,50.85 187.84,51.33 187.84,52.13 186.55,53.43 186.55,56.9 178.03,65.42 172.83,65.42 171.76,66.48 165.43,66.48 164.44,65.49 159.42,65.49 156.58,68.33 R411.1
HDA_BITCLK_L: length 2.3
  BOTTOM w0.102: R394.1 155.81,73.76 C460.1 R411.2
HDA_BITCLK_R: length 4.5
  BOTTOM w0.076: R394.2 155.81,76.21 154.98,77.05 154.98,79.47 U14.AW8
HDA_RST#: length 181.9
  TOP w0.102: U10.11 302.08,32.28 301.66,31.86 301.66,31.44 300.69,30.47 v2(300.67,30.47)
  IN3 w0.114: v2(300.67,30.47) 300.26,30.87 300.26,34.01 299.35,34.92 298.38,34.92 297.65,35.66 291.5,35.66 290.86,36.3 288.54,36.3 288.24,36.6 288.24,36.69 287.75,37.18 285.4,37.18 283.42,39.15 281.62,39.15 280.91,39.86 278.02,39.86 277,40.89 276.31,40.89 276.25,40.94 272.56,40.94 271.66,41.85 271.66,42.89 268.84,45.71 259.24,45.71 257.46,43.93 251.37,43.93 249.56,42.12 241.07,42.12 240.07,41.11 238.15,41.11 237.1,42.16 230.08,42.16 229.28,41.36 219.52,41.36 219.13,40.98 203.46,40.98 202.99,41.45 199.84,41.45 191.91,49.39 v2(191.7,49.39)
  BOTTOM w0.102: v2(191.7,49.39) 191.7,49.36 191.22,48.88 190.61,48.88 190.3,48.57 189.52,48.57 188.78,49.31 188.78,51.7 187.01,53.47 187.01,56.94 178.46,65.49 178.46,66.13 177.93,66.66 175.29,66.66 174.56,65.92 172.82,65.92 171.91,66.84 165.29,66.84 165.08,66.63 165.08,66.63 164.3,65.85 159.93,65.85 157.41,68.36 157.41,71.28 157.08,71.61 R393.1
HDA_RST#_R: length 6.3
  BOTTOM w0.076: R393.2 155.43,77.34 155.43,78.78 155.56,78.91 155.56,80.25 155.63,80.32 155.63,80.73 U14.AU8
HDA_SDIN0: length 183
  TOP w0.102: R232.1 299.27,33.01 v2(298.88,32.61)
  IN3 w0.114: v2(191.53,47.61) 191.67,47.74 192.41,47.74 199.44,40.71 202.69,40.71 203.16,40.25 221.29,40.25 221.76,39.78 226.28,39.78 227.12,40.63 229.59,40.63 230.39,41.43 236.67,41.43 237.8,40.3 241.4,40.3 242.48,41.38 250.03,41.38 251.82,43.17 258.43,43.17 260.18,44.92 262.64,44.92 263.66,43.9 263.66,43.39 264.02,43.04 265.5,43.04 266.94,41.6 270.87,41.6 272.04,40.42 272.27,40.19 275.96,40.19 276,40.15 276.66,40.15 277.83,38.98 280.45,38.98 281.11,38.31 283.02,38.31 285.7,35.63 288.16,35.63 289.48,34.31 290.74,34.31 291.14,34.71 295.67,34.71 296.13,34.24 296.13,33.22 296.73,32.63 298.87,32.63 v2(298.88,32.61)
  BOTTOM w0.076: U14.AY10 154.39,78.98 154.39,76.85 154.01,76.47 154.01,73.62
  BOTTOM w0.102: v2(191.53,47.61) 191.36,47.61 190.65,46.9 189.38,46.9 187.56,48.72 187.56,50.6 187.13,51.03 187.13,51.84 185.76,53.21 185.76,56.68 177.73,64.71 172.11,64.71 171.05,65.77 165.73,65.77 164.74,64.78 157.97,64.78 153.65,69.1 153.65,70.19 154.01,70.55 154.01,73.62
HDA_SDOUT: length 176.2
  TOP w0.102: v2(290.62,33.71) 290.62,34 291.23,34.61 294.09,34.61 294.24,34.45 296.19,34.45 296.45,34.71 297.51,34.71 298.05,34.17 C322.1 298.14,34.26 298.14,34.65 298.53,35.03 300.51,35.03 300.57,35.09 301.25,35.09 301.35,35.19 302.08,35.19 302.17,35.28 U10.5
  IN3 w0.114: v2(290.62,33.71) 288.74,33.71 288.46,33.42 286.9,33.42 286.83,33.49 285.68,33.49 282.68,36.49 279.22,36.49 278.57,37.15 277.71,37.15 277.1,37.76 276.44,37.76 275.93,38.26 274.23,38.26 273.54,38.95 271.38,38.95 270.36,39.97 265.57,39.97 264.35,41.18 263.69,41.18 262.34,42.53 256.45,42.53 255.94,42.02 255.13,42.02 254.24,41.13 251.62,41.13 250.73,40.25 242.07,40.25 241.74,39.91 237.65,39.91 236.51,41.06 230.54,41.06 229.74,40.26 227.27,40.26 226.43,39.41 221.57,39.41 221.1,39.88 202.6,39.88 202.48,39.76 199.85,39.76 193.68,45.93 192.21,45.93 190.81,47.33 v2(190.33,47.33)
  BOTTOM w0.102: R408.1 154.67,72.4 155.46,71.61 155.46,68.52 158.83,65.14 164.59,65.14 165.58,66.13 171.36,66.13 172.42,65.06 177.88,65.06 186.12,56.82 186.12,53.35 187.49,51.98 187.49,51.18 187.92,50.75 187.92,48.87 189.22,47.56 v1(189.59,47.56) 190.1,47.56 v2(190.33,47.33)
HDA_SDOUT_R: length 8.8
  BOTTOM w0.076: R395.2 154.67,76.35 154.81,76.49 154.81,79.96 154.65,80.12 154.36,80.12 154.16,80.32 154.16,80.71 153.81,81.06 U14.AU11
  BOTTOM w0.102: R408.2 154.67,73.94 155.15,74.42 155.15,75.52 154.98,75.69 R395.2
HDA_SYNC: length 177.4
  TOP w0.102: U10.10 302.07,32.78 301.85,32.56 301.39,32.56 301.25,32.42 301.25,31.53 301.15,31.43 300.68,31.43 C335.2 299.76,31.43 298.97,31.43 298.66,31.12 v2(298.37,31.12)
  IN3 w0.114: v2(298.37,31.12) 297.86,31.64 293.56,31.64 292.67,32.52 290.43,32.52 289.9,31.99 287.89,31.99 286.83,33.06 285.45,33.06 282.39,36.12 279.06,36.12 278.44,36.74 277.4,36.74 276.77,37.37 276.28,37.37 275.79,37.86 271.95,37.86 270.21,39.6 264.79,39.6 264.14,40.25 257.53,40.25 257.02,40.75 251.87,40.75 251,39.88 242.24,39.88 241.91,39.55 237.36,39.55 237.03,39.88 227.41,39.88 226.58,39.04 221.41,39.04 220.95,39.51 202.75,39.51 202.62,39.38 199.55,39.38 193.38,45.55 191.78,45.55 v2(190.89,46.44)
  BOTTOM w0.102: R409.1 153.53,71.26 153.3,71.03 153.3,68.62 157.49,64.43 164.88,64.43 165.88,65.42 170.9,65.42 171.97,64.35 177.58,64.35 185.41,56.53 185.41,52.21 187.21,50.41 187.21,48.57 189.33,46.44 v2(190.89,46.44)
HDA_SYNC_R: length 8.2
  BOTTOM w0.076: U14.AV11 153.81,80.4 154.23,79.98 154.23,77.01 153.53,76.31 R396.2 152.87,75.03 152.87,73.75 153.09,73.53 R409.2
HDMI_CLK_SINK: length 30.4
  TOP w0.102: U2.32 307.2,84.06 307.07,83.93 306.77,83.93 306.36,84.35 306.36,86.12 v2(306.64,86.4)
  IN1 w0.114: v2(312.59,89.47) 312.83,89.72 312.83,90.89 312.48,91.25 307.81,91.25 306.37,89.81 306.37,86.66 v2(306.64,86.4)
  BOTTOM w0.102: CN3.15 319.62,86.58 319.62,85.02 319.12,84.52 316.21,84.52 315.86,84.87 v1(315.04,84.87) 315.04,85.69 314.71,86.02 313.57,86.02 312.78,86.8 312.78,89.27 v2(312.59,89.47) RP18.2
HDMI_DAT_SINK: length 30.3
  TOP w0.102: v2(305.88,86.4) 306.15,86.12 306.15,84.26 306.69,83.73 307.07,83.73 307.14,83.66 U2.33
  IN1 w0.114: v2(305.88,86.4) 306.14,86.66 306.14,89.91 307.71,91.48 312.57,91.48 313.06,90.99 313.06,89.67 v2(313.24,89.5)
  BOTTOM w0.102: RP18.4 v2(313.24,89.5) 312.99,89.25 312.99,86.89 313.66,86.22 314.8,86.22 315.25,85.77 v1(315.94,85.77) 315.94,85.08 316.3,84.72 319.03,84.72 319.41,85.1 319.41,86.07 318.78,86.7 CN3.16
HDMI_PD#_LPT: length 271.2
  TOP w0.102: R75.1 305.43,85.72 305.24,85.53 305.24,82.66 305.09,82.51 v1(305.09,74) 305.09,72.48 301.79,69.18 301.79,68.72 302.42,68.08 303.41,68.08 v2(304.07,67.42) ; v2(157.03,94.92) 157.44,95.33 157.85,95.33 157.95,95.24 158.66,95.24 160.08,96.66 161.41,96.66 162.08,97.33 162.71,97.33 164.66,99.27 166.27,99.27 v1(166.66,99.66) 166.95,99.96 168.59,99.96 169.27,99.27 171.18,99.27 171.86,99.96 173.21,99.96 173.48,100.23 173.48,100.94 173.75,101.21 R32.1
  IN1 w0.089: v2(157.03,94.92) 157.03,95.01 157.39,95.36 158.01,95.36 158.24,95.13 159.62,95.13 160.13,94.63 162.7,94.63 162.85,94.47 165.74,94.47 166.84,93.38 168.31,93.38 169.22,92.47 169.22,90.48 168.75,90.01 168.75,87.56 170.49,85.83 172.5,85.83 173.16,85.16 173.16,78.07 171.42,76.33 171.42,72.39 172.96,70.85 172.96,68.06 174.22,66.79 174.22,65.98 175.25,64.95 175.25,64.91 185.61,54.55 185.61,51 186.64,49.97 186.64,46.39 187.02,46.01 187.02,45.21 192.86,39.37 193.47,39.37 197.02,35.82 197.02,33.81 197.75,33.08 200.02,33.08 200.97,34.03 203.33,34.03 207.03,30.34 208.8,30.34 209.95,29.18 218.78,29.18 219.48,29.89 221.8,29.89 222.25,30.34 230.88,30.34 231.37,30.83 234.64,30.83 236.79,32.98 243.94,32.98 244.58,33.62 249.46,33.62 249.96,33.12 252.48,33.12 253.3,33.94 256.71,33.94 257.11,33.54 260.87,33.54 261.37,34.05 264.37,34.05 266.5,31.91 267.9,31.91 269.9,29.92 279.98,29.92 281.31,31.25 281.31,34.61 280.98,34.94 280.98,35.95 282.71,37.68 282.71,44.36 285.35,47 285.35,47.19 286.2,48.04 286.53,48.04 286.55,48.02 287.05,48.02 288.76,49.72 291.04,49.72 293.43,52.11 294.14,52.11 296.56,54.53 296.92,54.88 296.92,57.22 301.14,61.44 302.03,61.44 304.69,64.09 304.69,66.07 304.07,66.69 v2(304.07,67.42)
  BOTTOM w0.102: U14.N6 156.86,94.75 v2(157.03,94.92)
HDMI_SCL: length 239.1
  TOP w0.102: v2(154.95,102.32) 155.25,102.63 155.25,102.75 154.21,103.79 154.21,104.6 152.79,106.02 152.79,107.28 152.57,107.5 RP2.1 152.27,107.99 v2(151.93,107.99) ; U2.38 307.09,81.66 306.99,81.56 306.75,81.56 v2(306.44,81.87)
  IN1 w0.114: v2(306.44,81.87) 306.44,81.72 306.15,81.44 305.8,81.44 305.03,80.68 305.03,72.31 302.74,70.02 302.74,68.71 301.81,67.77 301.81,67.26 300.84,66.29 300.84,65.98 300.45,65.59 300.45,64.67 298.73,62.95 298.73,62.47 296.33,60.07 296.33,60.05 288.55,52.27 286.58,52.27 285.81,51.5 284.52,51.5 283.77,50.74 282.92,50.74 281.14,48.96 278.79,48.96 277.29,47.46 260.87,47.46 257.73,44.31 250.3,44.31 249.33,43.34 235.47,43.34 235.14,43.67 233.15,43.67 232.79,43.32 224.2,43.32 223.85,43.67 220.94,43.67 220.2,42.92 201.52,42.92 198.05,46.39 198.05,53.76 193.2,58.61 192.57,58.61 188.43,62.75 187.91,62.75 185.56,65.1 185.56,66.28 183.47,68.36 183.47,70.26 182.35,71.38 182.35,80.03 183.02,80.69 183.02,81.43 183.78,82.19 183.78,83.29 183.57,83.49 183.57,86.81 183.93,87.17 183.93,88.99 181.62,91.3 181.62,92.06 180.37,93.31 180.37,93.79 179.84,94.32 179.84,95.64 178.9,96.58 178.9,97.62 178.19,98.33 178.19,99.06 174.92,102.33 174.46,102.78 172.68,102.78 171.62,103.84 164.96,103.84 163.62,105.17 160.89,105.17 159.62,106.44 159.13,106.93 159.13,107.54 157.31,109.36 153.96,109.36 153.35,108.75 152.69,108.75 v2(151.93,107.99)
  BOTTOM w0.076: U14.B9 154.43,100.91 154.53,100.81 154.67,100.81 154.81,100.95 154.81,101.28 155.15,101.62 155.15,102.12 v2(154.95,102.32)
HDMI_SDA: length 239.1
  TOP w0.102: v2(306.44,81.11) 306.68,81.36 306.99,81.36 307.09,81.26 U2.39 ; v2(153.88,107.99) 153.51,107.99 RP2.3 153.22,107.5 152.99,107.28 152.99,106.11 154.41,104.68 154.41,103.87 155.46,102.83 155.46,102.45 v2(155.58,102.32)
  IN1 w0.114: v2(153.88,107.99) 152.87,107.99 152.69,108.16 152.69,108.31 152.9,108.52 153.44,108.52 154.05,109.13 157.22,109.13 158.9,107.44 158.9,106.83 160.79,104.95 163.53,104.95 164.86,103.61 171.52,103.61 172.58,102.55 174.37,102.55 175.14,101.78 177.96,98.96 177.96,98.24 178.67,97.53 178.67,96.49 179.61,95.55 179.61,94.23 180.15,93.69 180.15,93.21 181.39,91.97 181.39,91.2 183.7,88.89 183.7,87.26 183.35,86.9 183.35,83.4 183.55,83.2 183.55,82.28 182.79,81.52 182.79,80.78 182.13,80.12 182.13,71.28 183.24,70.17 183.24,68.27 185.33,66.19 185.33,65.01 187.82,62.52 188.33,62.52 192.47,58.38 193.11,58.38 197.82,53.66 197.82,46.3 201.42,42.7 220.29,42.7 221.04,43.45 223.75,43.45 224.11,43.09 232.89,43.09 233.24,43.45 235.05,43.45 235.38,43.12 249.43,43.12 250.4,44.08 257.82,44.08 260.97,47.23 277.38,47.23 278.88,48.73 281.23,48.73 283.02,50.52 283.86,50.52 284.62,51.27 285.9,51.27 286.67,52.04 288.64,52.04 296.56,59.95 296.56,59.97 298.96,62.37 298.96,62.85 300.68,64.57 300.68,65.5 301.07,65.88 301.07,66.2 302.04,67.17 302.04,67.68 302.97,68.61 302.97,69.93 305.26,72.22 305.26,80.59 305.89,81.22 306.33,81.22 v2(306.44,81.11)
  BOTTOM w0.076: v2(155.58,102.32) 155.3,102.04 155.3,101.56 154.96,101.22 154.96,100.71 U14.C9
HDMI_SINK: length 30
  TOP w0.102: v2(309.08,86.3) 309.08,86.07 309.12,86.03 U2.28
  IN1 w0.089: v2(309.08,86.3) 309.79,87.01 313.52,87.01 315.96,84.57 319.6,84.57 CN3.19
  IN3 w0.114: v2(309.08,86.3) 307.35,84.57 307.35,80.25 307.02,79.92 305.06,79.92 304.94,79.79 304.94,77.48 304.45,77 v2(304.45,75.58)
  BOTTOM w0.102: Q40.2 304.78,74.79 v1(304.73,74.84) 304.45,75.12 v2(304.45,75.58)
HPD_HDMI_PD#: length 10.3
  TOP w0.102: R82.1 305.67,82.49 v2(305.49,82.31)
  BOTTOM w0.102: v2(305.49,82.31) 305.49,82.23 305.04,81.77 v1(305.04,80.25) 305.04,79.26 304.86,79.08 304.86,76.61 R384.1 305.43,75.56 Q40.3
HSPI_CS#: length 8.6
  TOP w0.102: R204.2 206.48,36.56 208.72,38.8 208.72,39.28 208.24,39.76 v1(208.24,40.14) 208.01,40.37 206.49,40.37 R179.2 R176.2
HWPG: length 216.3
  TOP w0.102: v2(185.89,25.16) 185.89,27.67 186.39,28.18 186.39,32.32 v1(183.56,35.15) 182.85,35.86 R205.1 182.85,36.73 183.02,36.9 183.5,36.9 183.63,37.03 R196.1 R189.1 C269.1 183.63,46.73 187.64,50.74 188.25,50.74 190.25,52.74 192.11,52.74 193.84,54.47 193.84,55.05 v2(194.22,55.43)
  IN1 w0.089: v2(185.89,25.16) 186.26,25.16 186.86,24.56 187.53,24.56 190.47,21.63 190.48,21.63 190.87,21.63 190.87,21.63 198.16,21.63 198.6,21.18 201.87,21.18 202.1,21.18 204.84,18.44 204.87,18.44 204.99,18.32 222.15,18.32 v2(224.77,20.94)
  IN2 w0.114: v2(212.3,116.01) 213.17,115.14 218.68,115.14 223.83,109.99 224.35,109.99 224.63,109.71 224.63,90.14 224.3,89.81 224.3,84.47 223.74,83.92 223.74,81.94 223.12,81.32 223.12,73.44 220.68,71 211.51,71 202.22,80.3 198.99,80.3 194.12,75.42 190.64,75.42 188.98,73.76 188.4,73.76 185.83,71.19 185.83,69.23 186.33,68.73 186.33,60.27 188.37,58.23 190.63,58.23 193.55,55.31 194.09,55.31 v2(194.22,55.43)
  BOTTOM w0.102: PD6.2 214.07,118.31 214.33,118.04 214.33,116.72 213.62,116.01 v2(212.3,116.01) ; U23.109 229.09,28.92 228.84,28.66 228.84,23.94 226.86,21.96 225.31,21.96 224.77,21.42 v2(224.77,20.94)
I2C_CK0: length 17.1
  TOP w0.102: RP4.2 172.42,105.07 172.27,105.22 171.94,105.22 169.27,102.55 168.87,102.55 164.34,102.55 163,101.21 162.14,101.21 161,100.06 160.41,100.06 159.14,98.8 v2(159.14,98.64)
  BOTTOM w0.076: v2(159.14,98.64) 158.84,98.34 U14.F3
I2C_CK1: length 116.5
  IN3 w0.114: v2(179.98,47.97) 180.47,48.46 182.84,48.46 183.51,49.13 183.51,50.69 183.16,51.03 180.96,51.03 180.05,50.13 176.35,50.13 172.17,54.3 172.17,57.18 173.55,58.56 173.55,58.75 173.56,58.75 173.56,62.55 172.6,63.51 172.6,68.79 174.82,71.01 179.04,71.01 179.47,71.43 179.47,75.99 178.83,76.63 178.83,79.7 178.09,80.44 178.09,82.77 178.44,83.11 178.44,84.09 178.06,84.47 178.06,87.15 178.78,87.86 178.78,91.98 178.66,92.1 178.66,94.67 171.24,102.09 167.01,102.09 163.03,98.11 161.3,98.11 v2(160.82,98.6)
  BOTTOM w0.076: U14.F1 160.52,98.3 v2(160.82,98.6)
  BOTTOM w0.102: v2(179.98,47.97) 180.17,47.78 180.17,46.23 181.72,44.67 181.72,41.52 182.86,40.37 182.86,32.8 v1(183.45,32.22) 183.45,30.29 183.9,29.84 R478.1 ; v2(160.82,98.6) 161.81,99.59 161.81,100.27 163.09,101.55 RP14.2
I2C_DA0: length 17
  TOP w0.102: v2(162.34,101.71) 163.66,103.03 169.07,103.03 171.74,105.7 172.3,105.7 172.32,105.72 RP4.4
  BOTTOM w0.076: U14.F2 159.6,98.26 160.06,98.72 160.35,98.72 161.15,99.52
  BOTTOM w0.102: 161.15,99.52 161.45,99.82 161.45,100.82 v2(162.34,101.71)
I2C_DA1: length 116.7
  IN3 w0.114: v2(180.6,47.97) 180.85,48.22 183.08,48.22 183.77,48.91 183.77,50.79 183.28,51.28 180.79,51.28 179.86,50.35 176.47,50.35 172.48,54.35 172.48,57.17 173.83,58.52 173.83,62.76 173.06,63.54 173.06,68.86 174.9,70.7 179.11,70.7 179.74,71.34 179.74,76.68 179.12,77.3 179.12,80.95 178.67,81.4 178.67,84.22 178.29,84.59 178.29,86.9 179.14,87.75 179.14,92.22 178.95,92.41 178.95,94.71 171.33,102.32 166,102.32 162.97,99.3 162.16,99.3 v2(161.45,98.59)
  BOTTOM w0.076: U14.G4 158.48,97.85 159.34,97.85 159.47,97.97 160.54,97.97 160.78,98.21 161.07,98.21 v2(161.45,98.59)
  BOTTOM w0.102: RP14.4 162.72,100.9 162.11,100.29 162.11,99.25 v2(161.45,98.59) ; v2(180.6,47.97) 180.44,47.8 180.44,46.24 181.94,44.74 181.94,41.62 183.04,40.52 183.04,40.48 183.07,40.46 183.07,34.71 v1(184.95,32.83) 185.3,32.47 185.3,31.47 R477.1
I2CA_SCL: length 5.3
  BOTTOM w0.102: R375.1 187.77,81.73 187.77,82.88 187.94,83.06 187.94,83.5 187.6,83.85 U13.B7
I2CA_SDA: length 5
  BOTTOM w0.102: R376.1 185.62,80.61 186.34,80.61 187.56,81.82 187.56,83.16 U13.A7
I2S_BCLK: length 56.9
  TOP w0.102: v2(273.19,41.91) 274.1,42.82 274.1,44.56 274.23,44.69 274.23,46.89 273.66,47.46 269.55,47.46 269.04,46.95 U7.35 ; R262.1 304.4,27.52 v2(304.66,27.27) 304.66,27.1 304.84,26.91 C359.2
  IN3 w0.114: v2(304.66,27.27) 304.85,27.46 304.85,32.59 303.01,34.42 302.55,34.42 301.65,35.32 300.62,35.32 298.66,37.27 295.66,37.27 294.48,38.46 292.61,38.46 292.08,37.93 285.97,37.93 283.08,40.83 281.97,40.83 281.77,40.63 279.38,40.63 277.91,42.1 273.37,42.1 v2(273.19,41.91)
I2S_LRCK_FS: length 54.6
  TOP w0.102: v2(305.95,28.43) 306.34,28.04 R264.1 ; v2(273.13,42.53) 273.74,43.14 273.74,44.71 273.87,44.84 273.87,46.54 v1(273.62,46.8) 273.34,47.07 269.73,47.07 269.44,46.78 U7.34
  IN3 w0.114: v2(305.95,28.43) 305.28,29.11 305.28,32.75 302.22,35.81 302.22,36.4 298.91,39.71 298.03,39.71 297.83,39.91 296.7,39.91 295.62,38.83 292.29,38.83 291.87,38.4 286.03,38.4 283.07,41.36 281.52,41.36 281.29,41.59 280.88,41.59 280.65,41.36 279.19,41.36 278.02,42.53 v2(273.13,42.53)
IINP: length 248
  TOP w0.254: PU3.7 v2(50.33,27.79) 50.51,27.79 51.17,27.13 PC57.1
  IN3 w0.114: v2(240.22,28.71) 240.06,28.56 237.04,28.56 236.49,29.11 234.48,29.11 233.13,30.46 232.92,30.68 230.24,30.68 229.88,30.68 229.39,30.19 227.12,30.19 226.8,29.87 219.88,29.87 218.84,28.83 211.36,28.83 210.49,29.69 209.94,29.69 209.71,29.69 208.93,30.47 199.94,30.47 199.84,30.57 199.84,30.57 199.44,30.97 199.3,31.1 199.1,31.3 197.17,31.3 196.98,31.3 196.85,31.44 196.31,31.97 194.84,33.44 189.41,33.44 185.61,37.25 155.76,37.25 155.53,37.48 152.78,37.48 152.18,36.88 140.66,36.88 138.29,36.88 137.64,36.23 119.49,36.23 118.83,36.89 109.72,36.89 102.03,29.2 91.99,29.2 90.34,27.55 89.31,27.55 89.3,27.53 89.09,27.32 89.09,27.32 87.44,25.67 84.9,25.67 84.09,24.86 75.76,24.86 74.37,26.25 67.56,26.25 67.55,26.26 57.65,26.26 56.75,27.16 55.99,27.16 53.7,29.45 51.98,29.45 v2(50.33,27.79)
  BOTTOM w0.102: U23.72 236.63,41.49 237.76,42.61 239.89,42.61 240.01,42.48 243.92,42.48 244.32,42.09 245.84,42.09 246.08,41.85 246.08,40.52 244.05,38.48 244.05,34.67 242.38,33.01 241.64,33.01 241.18,32.55 241.18,30.36 v1(240.37,29.55) 240.37,28.87 v2(240.22,28.71)
  BOTTOM w0.254: PR193.1 44.94,20.81 44.61,21.14 44.61,21.5 45.64,22.53 48.56,22.53 48.88,22.85 48.88,23.86 48.24,24.5 46.97,24.5 46.46,25.01 46.46,25.77 47.35,26.66 49.19,26.66 v2(50.33,27.79)
IMVP7_PROCHOT#: length 340
  TOP w0.102: v2(116.04,94.96) 115.89,94.96 115.56,95.29 114.64,95.29 114.56,95.36 113.49,95.36 112.4,96.45 112.4,99.55 111.79,100.16 111.79,103.26 v2(107.76,107.3) ; v2(110.09,57.26) 107.98,55.15 107.98,53.32 107.58,52.91 106.83,52.91 101.84,47.92 94.65,47.92 89.62,42.89 84.95,42.89 82.89,40.83 70.67,40.83 70.34,40.5 68.18,40.5 66.91,39.23 66.16,39.23 65.03,38.1 65.03,36.51 65.54,36 65.54,34.91 65.39,34.76 64.86,34.76 64.46,34.36 64,34.36 62.59,32.95 62.59,32.71 62.16,32.28 62.16,31.38 60.33,29.55 57.13,29.55 56.78,29.2 55.86,29.2 55.35,28.69 55.35,26.66 56.5,25.51 58.78,25.51 59.42,24.88 59.42,22.85 59.16,22.59 58.53,22.59 56.83,20.89 PQ21.3 56.83,18.91 57.18,18.55 58.2,18.55 58.79,19.15 PQ50.3
  IN1 w0.089: v2(110.09,57.26) 110.01,57.35 110.01,58.2 112.61,60.79 112.61,63.69 112.28,64.02 112.28,65.9 112.89,66.51 112.89,77.25 111.39,78.75 111.39,81.97 113.65,84.22 v2(113.65,85.08)
  IN2 w0.114: v2(116.09,97.12) 116.09,97.09 116.7,96.48 116.7,95.97 116.04,95.31 v2(116.04,94.96)
  IN3 w0.114: v2(107.76,107.3) 107.76,108.06 108.62,108.93 109.69,108.93 110.4,109.64 110.4,112.46 109.52,113.33 109.52,118.13 v2(112.91,121.53) ; v2(242.32,34.66) 242.32,33.9 241.79,33.36 232.27,33.36 232.04,33.59 231.01,33.59 230.94,33.66 226.45,33.66 225.94,33.15 220.1,33.15 219.36,32.41 218.76,32.41 218.55,32.19 210.75,32.19 209.04,33.9 198,33.9 197.64,34.26 195.58,36.32 195.58,36.32 193.86,38.04 191.8,38.04 190.2,39.64 188.38,39.64 182.7,45.32 179.22,45.32 178.76,45.77 176.59,45.77 176.01,46.35 176.01,46.43 175.56,46.89 175.18,47.27 168.56,53.88 168.56,58.74 v2(170.06,60.23)
  BOTTOM w0.076: 115.68,94.86 115.93,94.86 v2(116.04,94.96)
  BOTTOM w0.102: 115.68,94.86 R317.1 115.43,95.19 115.28,95.34 114.33,95.34 113.81,95.86 R311.1 112.82,95.28 112.82,92.84 112.07,92.09 112.07,91.27 112.38,90.97 112.38,90.25 111.94,89.81 111.94,86.91 v1(111.95,86.9) 111.95,86.6 113.19,85.36 113.37,85.36 v2(113.65,85.08) 114.51,84.22 115.85,84.22 118.32,81.75 118.32,75.47 120.12,73.67 123.07,73.67 129.47,67.27 139.05,67.27 150.07,56.25 166.07,56.25 v2(170.06,60.23) ; R309.1 116.06,97.14 v2(116.09,97.12) ; PR145.2 112.94,121.5 v2(112.91,121.53) ; Q43.3 241.94,35.04 v2(242.32,34.66)
IMVP_PWRGD: length 21.7
  TOP w0.102: v1(126.2,117.64) 125.33,116.78 D1.2 125.27,115.95 R491.1 124.8,114.12 124.8,113.12 v2(124.06,112.38) ; PR11.1 v2(114.26,116.83)
  IN3 w0.114: v2(124.06,112.38) 123.48,111.8 122.26,111.8 121.8,112.25 117.2,112.25 114.99,114.46 114.99,116.09 v2(114.26,116.83)
  BOTTOM w0.178: PU9.3 114.19,116.76 v2(114.26,116.83)
IMVP_VR_ON: length 174
  TOP w0.102: v2(190.38,64.93) 190.08,64.93 188.2,63.05 v1(188.2,60.64) v2(188.73,60.11)
  IN1 w0.089: v2(190.38,64.93) 190.16,64.93 189.98,65.11 189.45,65.11 188.72,65.84 188.72,66.57 187.2,68.09 187.2,68.81 186,70.01 186,73.57 185.11,74.46 185.11,77.16 185.87,77.92 185.87,78.71 187.29,80.13 187.29,85.51 188.4,86.63 188.4,87.37 187.41,88.36 187.41,90 185.05,92.37 185.05,95.59 182.38,98.26 182.38,99.55 181.87,100.07 181.87,100.1 180.27,101.69 178.28,101.69 173.03,106.95 171.61,106.95 169.48,104.82 165.56,104.82 162.44,107.94 159.9,107.94 156.26,111.57 151.92,111.57 149.43,109.08 144.48,109.08 143.95,109.61 140.19,109.61 138.45,107.87 134.23,107.87 132.97,106.61 v2(132.76,106.61)
  BOTTOM w0.076: 131.71,107.71 132.76,106.66 v2(132.76,106.61)
  BOTTOM w0.102: PR162.2 118.48,113.74 118.75,113.47 120.1,113.47 120.66,112.91 120.66,110.15 121.24,109.56 124.21,109.56 125.28,110.63 128.79,110.63 131.71,107.71 ; v2(188.73,60.11) 188.73,59.5 189.9,58.33 189.9,54.3 191.35,52.85 191.35,52.08 192.75,50.68 192.75,48.88 193.56,48.07 198.1,48.07 198.31,47.87 198.31,45.12 199.98,43.45 200.91,43.45 205.48,43.45 205.82,43.11 205.82,42.86 205.82,42.52 205.82,42.12 209.48,38.47 214.04,38.47 R467.1 215.18,38.44 216.64,38.44 217.1,37.98 217.1,37.73 217.38,37.45 218.37,37.45 218.81,37.89 U23.16
INT_HDMI_HP: length 230
  TOP w0.102: v2(302.22,68.9) 305.07,71.75 308.5,71.75 308.64,71.89 308.64,73.44 v1(308.24,73.85) 307.6,74.49 307.6,77.27 307.96,77.63 307.96,77.94 309.12,79.1 U2.3
  IN1 w0.114: v2(302.22,68.9) 301.13,67.8 301.13,67.28 300.34,66.5 300.34,66.18 299.96,65.8 299.96,64.87 298.24,63.15 298.24,62.67 295.84,60.27 295.84,60.25 288.58,53 287.43,53 287.43,52.99 287.09,52.99 287.08,53 286.32,53 285.35,52.03 284.35,52.03 283.58,51.26 282.52,51.26 280.72,49.45 278.58,49.45 277.3,48.17 260.51,48.17 258,45.66 250.95,45.66 249.47,44.18 246.08,44.18 245.19,45.07 239.33,45.07 238.21,43.95 236.76,43.95 236.16,44.55 221.08,44.55 219.95,43.42 201.92,43.42 198.56,46.78 198.56,53.99 192.41,60.14 191.75,60.14 191.3,60.59 190.2,61.68 186.95,64.94 186.77,64.94 186.05,65.66 186.05,66.56 185.3,67.31 185.3,68.03 184.06,69.28 184.06,71.72 183.14,72.63 183.14,75.17 183.35,75.38 183.35,78.61 184,79.25 184.15,79.25 185.35,80.46 185.35,85.99 184.89,86.45 184.89,89.53 183.38,91.04 183.38,94.11 180.02,97.47 180.02,98.41 178.47,99.96 178.39,99.96 178.11,99.96 175.1,102.98 174.58,103.49 172.67,103.49 171.82,104.34 165.36,104.34 163.54,106.16 162.69,106.16 v2(162.65,106.21)
  BOTTOM w0.076: 158.53,102.91 157.31,102.91 156.83,102.42 156.83,101.71 156.35,101.23 156.35,100.98 155.91,100.54 U14.C8
  BOTTOM w0.102: R287.2 162.55,107.78 162.59,107.74 162.59,106.26 v2(162.65,106.21) 162.44,106 162.44,104.93 160.78,103.26 159.01,103.26 158.66,102.91 158.53,102.91
INT_HDMI_TXCN: length 290.9
  TOP w0.114: C185.1 313.26,76.21 313.04,76.21 312.91,76.08 312.91,75.22 313.09,75.04 v2(313.44,75.04)
  IN3 w0.102: v2(175.37,54.95) 175.74,54.95 176.07,55.28 191.12,55.28 194.43,51.97 194.96,51.97 197.24,49.69 197.24,47.87 201.23,43.88 207.64,43.88 207.99,43.53 220.28,43.53 221.15,44.4 229.63,44.4 230.33,45.1 239.09,45.1 239.29,45.3 247.51,45.3 248.45,46.24 250.3,46.24 251.92,47.86 262.88,47.86 263.01,47.99 277.91,47.99 279.26,49.34 281.16,49.34 282.1,50.28 284.39,50.28 286.25,52.13 288.38,52.13 290.89,54.65 291.22,54.65 300.74,64.17 301.07,64.17 303.34,66.43 303.34,67.71 304.53,68.9 304.53,73.21 305.8,74.48 309.69,74.48 310.07,74.87 310.07,78.15 310.31,78.4 310.99,78.4 311.23,78.15 311.23,76.62 311.36,76.49 311.87,76.49 312,76.62 312,77.95 312.24,78.19 313.15,78.19 313.39,77.95 313.39,76.1 312.99,75.7 312.99,75.2 313.15,75.04 v2(313.44,75.04)
  BOTTOM w0.076: U14.A57 125.37,101.57 125.45,101.49 125.52,101.49 126.58,102.54 126.58,102.76 126.53,102.81 126.53,102.83
  BOTTOM w0.114: v2(175.37,54.95) 175.37,54.7 174.23,53.55 147.4,53.55 135.75,65.21 126.55,65.21 116.75,75.02 114.77,75.02 v1(114.26,75.53) 113.75,75.02 113.36,75.02 109.7,78.68 109.7,85.96 110.4,86.66 110.4,91.1 110.65,91.35 110.65,92.6 111.45,93.4 111.45,98.85 113.6,101 118.02,101 121.17,104.15 125.73,104.15 126.53,103.36 126.53,102.83
INT_HDMI_TXCN_C: length 4
  TOP w0.114: U2.10 311.92,79.6 311.84,79.52 311.84,79.36 313.04,78.17 313.04,77.21 C185.2
INT_HDMI_TXCN_L: length 10.6
  TOP w0.114: CN3.12 318.35,89.04 317.58,89.04 v1(317.08,88.53) 316.57,89.04 315.96,89.04 315.39,88.47 315,88.47 314.31,89.16 314.31,89.55 314.56,89.8 314.56,90.53 314.43,90.66 313.94,90.66 R59.2 313.41,90.66 312.43,90.66 312.3,90.79 311.88,90.79 311.73,90.64 EL4.3
INT_HDMI_TXCN_R: length 16.4
  TOP w0.114: U2.21 311.92,85.66 311.78,85.8 311.78,87.59 311.91,87.72 312.48,87.72 312.61,87.59 312.61,86.82 312.88,86.55 314.16,86.55 314.43,86.82 314.43,87.39 v1(314.94,87.9) 314.59,87.9 314.31,88.17 314.31,88.46 313.83,88.94 312.23,88.94 312.07,89.09 312.07,89.5 311.59,89.98 309.33,89.98 309.14,90.17 309.14,90.83 309.25,90.94 309.46,90.94 309.76,90.64 EL4.4
INT_HDMI_TXCP: length 291
  TOP w0.114: C184.1 312.66,75.8 312.66,75.18 v2(312.51,75.04)
  IN3 w0.102: v2(312.51,75.04) 312.78,75.31 312.78,75.78 313.19,76.19 313.19,77.86 313.06,77.99 312.33,77.99 312.2,77.86 312.2,76.53 311.95,76.29 311.28,76.29 311.03,76.53 311.03,78.07 310.9,78.19 310.4,78.19 310.27,78.07 310.27,74.78 309.77,74.28 305.88,74.28 304.73,73.13 304.73,68.82 303.54,67.63 303.54,66.35 301.16,63.97 300.83,63.97 291.3,54.44 290.98,54.44 288.46,51.93 286.33,51.93 284.48,50.07 282.19,50.07 281.25,49.14 279.35,49.14 278,47.79 263.09,47.79 262.96,47.66 252.01,47.66 250.39,46.04 248.53,46.04 247.59,45.1 239.38,45.1 239.17,44.89 230.41,44.89 229.71,44.19 221.23,44.19 220.37,43.33 207.91,43.33 207.56,43.68 201.14,43.68 197.04,47.79 197.04,49.6 194.88,51.76 194.35,51.76 191.03,55.08 176.16,55.08 175.83,54.75 v2(175.83,54.52)
  BOTTOM w0.076: 126.78,102.83 126.78,102.81 126.73,102.76 126.73,102.48 125.58,101.34 125.45,101.34 125.37,101.26 U14.B57
  BOTTOM w0.114: v2(175.83,54.52) 175.55,54.52 174.33,53.3 147.3,53.3 135.64,64.96 126.45,64.96 116.64,74.76 114.77,74.76 v1(114.26,74.26) 113.75,74.76 113.25,74.76 109.44,78.57 109.44,86.07 110.14,86.77 110.14,91.2 110.4,91.46 110.4,92.71 111.2,93.51 111.2,98.96 113.5,101.26 117.91,101.26 121.06,104.41 125.84,104.41 126.78,103.47 126.78,102.83
INT_HDMI_TXCP_C: length 4
  TOP w0.114: U2.9 311.52,79.6 311.59,79.52 311.59,79.26 312.78,78.06 312.78,77.21 C184.2
INT_HDMI_TXCP_L: length 10.7
  TOP w0.114: EL4.2 311.73,91.19 311.88,91.05 312.41,91.05 312.53,90.92 313.41,90.92 R59.1 313.94,90.92 314.54,90.92 314.82,90.64 314.82,89.7 314.56,89.45 314.56,89.27 315.11,88.72 315.29,88.72 315.86,89.29 316.57,89.29 v1(317.08,89.8) 317.58,89.29 318.28,89.29 CN3.10
INT_HDMI_TXCP_R: length 16.4
  TOP w0.114: EL4.1 309.15,91.19 308.89,90.93 308.89,90.06 309.23,89.72 311.49,89.72 311.82,89.39 311.82,88.98 312.12,88.68 313.72,88.68 314.05,88.35 314.05,88.15 313.8,87.9 v1(313.67,87.9) 314.18,87.39 314.18,86.93 314.05,86.8 312.99,86.8 312.86,86.93 312.86,87.7 312.58,87.97 311.81,87.97 311.53,87.7 311.53,85.74 311.52,85.72 U2.22
INT_HDMI_TXN0: length 290.9
  TOP w0.114: v2(311.51,73.75) 311.29,73.98 311.29,75.02 311.03,75.27 311.03,75.82 C183.1
  IN3 w0.102: v2(311.51,73.75) 311.18,73.75 311.01,73.57 311.01,72.3 310.7,72 309.89,72 308.36,73.52 306.71,73.52 305.98,72.78 305.98,71.85 306.85,70.98 308.24,70.98 308.64,70.57 308.64,69.89 305.16,66.41 305.16,63.91 303.44,62.19 300.04,62.19 291.48,53.63 291.14,53.63 288.75,51.24 286.62,51.24 284.76,49.39 282.49,49.39 281.52,48.42 279.6,48.42 278.28,47.1 263.38,47.1 263.24,46.97 255.02,46.97 254.06,46.01 251.63,46.01 249.37,43.75 236.14,43.75 235.69,44.21 232.17,44.21 231.3,43.34 229.47,43.34 229.29,43.15 221.54,43.15 221.03,42.65 207.62,42.65 207.27,42.99 200.74,42.99 195.21,48.53 195.21,49.16 194.32,50.05 194.32,50.79 191.91,53.2 177.02,53.2 v2(176.74,52.92)
  BOTTOM w0.076: 127.59,102.83 127.59,102.81 127.54,102.76 127.54,102.5 127.19,102.14 127.19,101.56 126.97,101.34 126.83,101.34 126.75,101.26 U14.B55
  BOTTOM w0.114: 127.59,102.83 127.59,103.85 126.2,105.24 120.81,105.24 117.58,102.02 113.2,102.02 110.45,99.27 110.45,93.82 109.1,92.47 109.1,87.37 108.69,86.96 108.69,78.26 113.62,73.34 115.6,73.34 v1(116.11,72.83) 116.62,73.34 117,73.34 118.58,71.77 118.58,70.52 120.45,68.64 121.67,68.64 126.17,64.15 135.01,64.15 137.93,61.23 146.64,52.51 175.22,52.51 175.78,53.07 176.59,53.07 v2(176.74,52.92)
INT_HDMI_TXN0_C: length 4.1
  TOP w0.114: U2.7 310.72,79.6 310.64,79.52 310.64,79.14 310.88,78.9 310.88,78.42 v1(311.39,77.91) 310.88,77.41 310.88,77.21 C183.2
INT_HDMI_TXN0_L: length 15.4
  TOP w0.114: v2(314.97,91.45) 314.97,91.64 314.67,91.93 314.2,91.93 313.54,92.59 312.82,92.59 R55.2 312.39,92.44 311.88,92.44 311.73,92.29 EL3.3
  IN1 w0.102: CN3.9 320.24,90.4 320.06,90.58 319.65,90.58 319.25,90.99 319.25,94.27 319.03,94.49 317.71,94.49 316.71,93.48 316.71,92.56 316.11,91.96 315.48,91.96 v2(314.97,91.45)
INT_HDMI_TXN0_R: length 11.6
  TOP w0.114: EL3.4 309.43,92.29 309.35,92.37 309.35,92.47 309.23,92.59 308.52,92.59 308.24,92.31 308.24,91.83 307.81,91.4 307.81,91.1 v1(308.37,90.54) 307.75,89.93 307.75,89.55 308.23,89.07 308.96,89.07 310.57,87.47 310.57,85.79 310.72,85.64 U2.24
INT_HDMI_TXN1: length 290.3
  TOP w0.114: v2(308.99,75.19) 308.78,75.19 308.62,75.35 308.62,75.88 308.79,76.05 C181.1
  IN3 w0.102: v2(173.95,56.4) 174.1,56.25 174.3,56.25 175.08,57.03 191.6,57.03 198.03,50.61 198.03,48.23 201.69,44.57 207.93,44.57 208.28,44.22 220,44.22 220.86,45.08 229.3,45.08 229.99,45.78 238.39,45.78 238.87,46.26 247.5,46.26 248.71,47.47 250.44,47.47 251.52,48.55 262.59,48.55 262.75,48.7 277.66,48.7 278.98,50.02 280.83,50.02 281.8,50.99 284.13,50.99 285.96,52.82 288.1,52.82 290.64,55.36 290.86,55.36 300.62,65.11 300.62,66.26 303.51,69.16 303.51,73.27 305.7,75.45 305.7,78.45 305.94,78.7 307.91,78.7 308.19,78.98 308.19,80.78 308.42,81.01 309.25,81.01 309.53,80.73 309.53,77.73 309.24,77.43 307.02,77.43 306.89,77.3 306.89,76.52 307.02,76.39 308.35,76.39 308.64,76.09 308.64,75.45 308.9,75.19 v2(308.99,75.19)
  BOTTOM w0.076: U14.B58 124.81,100.62 124.71,100.52 124.57,100.52 124.47,100.62 124.47,100.84 124.81,101.18 124.81,101.33 124.93,101.45 124.93,101.99 125.18,102.25 125.65,102.25 125.79,102.39 125.79,102.74 125.74,102.79 125.74,102.81
  BOTTOM w0.114: 125.74,102.81 125.74,103.06 125.57,103.22 121.31,103.22 118.33,100.24 113.92,100.24 112.2,98.52 112.2,93.09 111.41,92.3 111.41,91.05 111.18,90.82 111.18,86.17 111.78,85.58 111.78,84.96 v1(112.3,84.44) 111.74,83.88 111.74,83.07 110.93,82.26 110.93,78.51 113.12,76.31 116.59,76.31 126.86,66.05 136.21,66.05 147.94,54.32 172.37,54.32 174.13,56.07 174.13,56.22 v2(173.95,56.4)
INT_HDMI_TXN1_C: length 4
  TOP w0.114: U2.5 309.92,79.67 309.84,79.59 309.84,78.55 308.72,77.43 308.72,77.21 C181.2
INT_HDMI_TXN1_L: length 10.8
  TOP w0.114: EL2.3 311.73,93.94 311.88,94.09 313.28,94.09 R52.2 313.81,94.09 316.04,94.09 316.19,93.94 316.19,93.74 315.53,93.08 315.53,92.67 316.12,92.07 316.73,92.07 v1(317.28,91.53) 317.83,92.07 318.31,92.07 CN3.6
INT_HDMI_TXN1_R: length 17
  TOP w0.114: EL2.4 309.55,93.94 309.46,94.04 309.46,94.16 309.38,94.24 308.97,94.24 308.86,94.13 308.86,93.77 308.6,93.51 307.93,93.51 307.67,93.77 307.67,94.13 307.55,94.24 307.25,94.24 306.66,93.66 306.66,92.49 v1(307.25,91.91) 306.64,91.3 306.64,90.99 306.15,90.51 306.15,90.08 306.39,89.84 306.39,89.47 306.18,89.26 306.18,88.84 306.3,88.72 306.61,88.72 306.88,88.99 307.25,88.99 308.24,88 308.8,88 309.77,87.03 309.77,85.8 309.92,85.66 U2.26
