# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_BS#0: length 70.6
  IN1 w0.076: v2(139.02,84.5) 138.6,84.07 137.87,84.07 137.68,83.88 137.68,83.37 137.9,83.15 138.21,83.15 138.54,82.82 138.54,79.84 138.08,79.39 137.68,79.39 137.02,78.73 137.02,74.87 136.97,74.81 136.97,74.46
  IN1 w0.14: 136.97,74.46 136.97,61.61 142.5,56.07 142.5,55.87 141.98,55.35 141.98,55.17 142.26,54.89 142.44,54.89 142.93,55.37 143.13,55.37 143.32,55.17 143.32,54.97 142.86,54.51 142.86,54.31 143.06,54.12 143.25,54.12 143.72,54.58 143.92,54.58 144.11,54.38 144.11,54.18 143.65,53.72 143.65,53.52 143.85,53.33 144.04,53.33 144.51,53.79 144.71,53.79 144.9,53.59 144.9,53.39 144.44,52.93 144.44,52.73 144.64,52.53 144.83,52.53 145.3,53 145.5,53 145.69,52.8 145.69,52.6 145.23,52.14 145.23,51.94 145.43,51.74 145.63,51.74 146.09,52.21 146.29,52.21 146.48,52.01 146.48,51.81 146.02,51.35 146.02,51.15 146.25,50.93 146.44,50.93 146.92,51.4 147.12,51.4 147.32,51.21 147.32,51.01 146.84,50.53 146.84,50.33 147.04,50.14 147.23,50.14 147.71,50.61 147.91,50.61 148.11,50.41 148.11,50.22 147.63,49.74 147.63,49.54 150.17,47 150.17,44.91 150.86,44.22 150.86,40.65 150.73,40.52 149.64,40.52 149.51,40.65 149.51,40.91 149.64,41.03 150.2,41.03 150.43,41.26 v2(150.43,41.87)
  BOTTOM w0.165: JDIM1.109 150.41,43.89 150.87,43.44 150.87,42.31 v2(150.43,41.87) ; U14.AL35 139.09,84.5 v2(139.02,84.5)
M_B_BS#1: length 70.2
  IN1 w0.076: 137.31,74.15 137.31,74.92 137.18,75.04 137.18,78.56 137.7,79.08 138.16,79.08 138.77,79.69 138.77,82.89 138.07,83.59 v2(138.07,83.68)
  IN1 w0.14: v2(149.59,38.82) 149.26,38.82 149.13,38.7 149.13,38.01 148.95,37.83 148.09,37.83 147.96,37.96 147.96,38.21 148.09,38.34 148.5,38.34 148.62,38.47 148.62,39.05 148.92,39.35 148.92,40.04 149.05,40.17 149.36,40.17 149.49,40.04 149.49,39.41 149.61,39.28 150,39.28 150.12,39.41 150.12,40.02 150.25,40.14 150.55,40.14 150.68,40.02 150.68,39.41 150.81,39.28 151.04,39.28 151.24,39.48 151.24,44.87 151.11,44.99 150.64,44.99 150.52,45.12 150.52,45.38 150.64,45.5 150.94,45.5 151.06,45.63 151.06,45.91 150.94,46.04 150.64,46.04 150.52,46.16 150.52,47.36 150.96,47.8 150.96,48 150.76,48.19 150.56,48.19 150.11,47.74 149.91,47.74 149.72,47.94 149.72,48.14 150.17,48.59 150.17,48.79 149.97,48.98 149.77,48.98 149.32,48.53 149.12,48.53 148.95,48.71 148.95,48.96 149.42,49.43 149.42,49.63 149.23,49.83 149.03,49.83 148.55,49.35 148.36,49.35 148.16,49.55 148.16,49.75 148.63,50.22 148.63,50.42 137.31,61.75 137.31,74.15
  BOTTOM w0.165: v2(138.07,83.68) U14.AM36 ; v2(149.59,38.82) 150.11,38.3 JDIM1.108
M_B_BS#2: length 66.8
  IN1 w0.14: v2(139.17,40.32) 137.98,41.52 137.7,41.52 137.56,41.65 137.56,42.26 137.42,42.4 137.14,42.4 137,42.26 137,41.65 136.86,41.52 135.44,41.52 135.01,41.95 135.01,42.96 125.74,52.23 125.54,52.23 125.12,51.81 124.92,51.81 124.72,52.01 124.72,52.21 125.14,52.63 125.14,52.83 124.95,53.03 124.75,53.03 124.32,52.6 124.13,52.6 123.93,52.8 123.93,53 124.35,53.42 124.35,54.2 124.16,54.39 123.15,54.39 123.02,54.52 123.02,54.88 123.15,55 124.29,55 124.42,55.13 124.42,55.43 124.29,55.56 123.12,55.56 123,55.69 123,55.99 123.12,56.12 124,56.12 124.14,56.26 124.14,56.54 124,56.68 123.59,56.68 123.45,56.82 123.45,74.05 126.6,77.2 126.6,77.86 128.76,80.02 129.53,80.02 v2(130.27,80.76)
  BOTTOM w0.102: U14.AU49 130.57,81.06 v2(130.27,80.76)
  BOTTOM w0.165: v2(139.17,40.32) 141.41,42.56 JDIM1.79
M_B_CAS#: length 70.4
  IN1 w0.076: v2(139.98,83.91) 140.37,83.52 140.37,79.87 139.52,79.02 139.52,78.13
  IN1 w0.14: v2(152.1,42.05) 152.59,42.05 152.64,42 152.64,37.78 152.76,37.65 153.04,37.65 153.17,37.78 153.17,44.72 153.7,45.25 153.7,46.86 153.56,47 153.13,47 152.99,47.14 152.99,47.42 153.13,47.56 153.56,47.56 153.7,47.7 153.7,48.02 153.03,48.69 152.83,48.69 152.53,48.39 152.34,48.39 152.14,48.59 152.14,48.79 152.44,49.09 152.44,49.29 152.24,49.48 152.04,49.48 151.74,49.19 151.55,49.19 151.35,49.38 151.35,49.58 151.65,49.88 151.65,50.08 151.45,50.27 151.25,50.27 150.95,49.98 150.75,49.98 150.56,50.17 150.56,50.37 150.85,50.67 150.85,50.87 150.66,51.06 150.46,51.06 150.16,50.77 149.96,50.77 149.77,50.96 149.77,51.16 150.06,51.46 150.06,51.66 149.87,51.85 149.67,51.85 149.37,51.56 149.17,51.56 148.98,51.75 148.98,51.95 149.27,52.25 149.27,52.45 149.08,52.64 148.88,52.64 148.58,52.35 148.38,52.35 148.19,52.54 148.19,52.74 148.48,53.04 148.48,53.24 138.48,63.24 138.48,74.45 138.72,74.69 138.72,77.33 139.52,78.13
  BOTTOM w0.165: v2(152.1,42.05) 152.28,42.05 152.74,42.5 152.74,43.42 152.21,43.95 JDIM1.115 ; U14.AM33 140.16,83.91 v2(139.98,83.91)
M_B_CKE0: length 52.6
  IN1 w0.076: 128.25,77.76 129.55,79.06 129.9,79.06 v2(130.26,79.41)
  IN1 w0.14: v2(139.61,43.27) 138.18,43.27 136.61,44.84 134.6,44.84 125.46,53.99 125.46,57.36 125.32,57.5 124.7,57.5 124.57,57.63 124.57,57.93 124.7,58.06 125.32,58.06 125.46,58.2 125.46,58.48 125.32,58.62 124.63,58.62 124.49,58.76 124.49,59.04 124.63,59.18 125.32,59.18 125.46,59.32 125.46,59.6 125.33,59.73 124.62,59.73 124.49,59.85 124.49,73.62 128.25,77.38 128.25,77.76
  BOTTOM w0.165: v2(130.26,79.41) 130.37,79.41 U14.AY49 ; JDIM1.73 139.61,43.27 v2(139.61,43.27)
M_B_CKE1: length 55.5
  IN1 w0.076: 127.19,76.88 128,77.68 128,77.84 v2(130.26,80.1)
  IN1 w0.14: 127.19,76.88 124.1,73.79 124.1,57.54 125.07,56.58 125.07,53.82 134.44,44.45 136.45,44.45 139.96,40.93 v2(139.96,38.95)
  BOTTOM w0.076: U14.AU50 129.55,80.87 129.55,80.29 129.72,80.12 130.25,80.12 v2(130.26,80.1)
  BOTTOM w0.165: JDIM1.74 139.91,38.9 v2(139.96,38.95)
M_B_CLKN0: length 62.2
  IN1 w0.076: 136.8,81.77 136.79,81.79 136.79,81.84 136.55,82.08 136.55,82.86 136.72,83.04 136.72,83.69 136.88,83.85 v2(137.12,83.85)
  IN1 w0.102: v2(148.89,42.62) 148.89,42.24 149.04,42.09 149.22,42.09 149.5,42.37 149.5,43.86 148.19,45.17 148.19,46.52 137.61,57.1 137.61,57.63 137.4,57.85 136.83,57.85 136.39,58.28 136.39,58.88 136.2,59.07 135.64,59.07 135.1,59.61 135.1,60.11 135.54,60.55 135.54,60.79 135.38,60.96 134.95,60.96 134.63,61.28 134.63,61.73 134.94,62.05 135.38,62.05 135.54,62.21 135.54,62.49 135.38,62.66 134.92,62.66 134.62,62.97 134.62,63.45 134.92,63.75 135.38,63.75 135.54,63.92 135.54,64.2 135.38,64.36 134.9,64.36 134.62,64.64 134.62,65.18 134.89,65.45 135.38,65.45 135.54,65.62 135.54,65.9 135.38,66.06 134.92,66.06 134.62,66.37 134.62,66.85 134.92,67.15 135.38,67.15 135.62,67.4 135.62,67.79 135.38,68.03 134.9,68.03 134.62,68.32 134.62,68.85 134.9,69.13 135.38,69.13 135.48,69.23 135.48,72.45 135.06,72.87 135.06,74.28 136.29,75.51 136.29,79.11 137.05,79.87 137.05,81.52 136.8,81.77
  BOTTOM w0.114: U14.AM38 137.65,84.03 137.65,83.92 137.57,83.83 137.13,83.83 v2(137.12,83.85) ; JDIM1.103 148.61,43.67 148.44,43.5 148.44,43 148.29,42.86 148.29,42.28 148.42,42.15 148.67,42.15 148.89,42.37 v2(148.89,42.62)
M_B_CLKN1: length 60.8
  IN1 w0.076: v2(137.12,85.15) 136.89,84.92 136.4,84.92 136.1,84.62 136.1,81.83 136.06,81.79 136.06,81.77
  IN1 w0.102: 136.06,81.77 136.06,81.34 135.83,81.11 135.83,79.72 135.09,78.97 135.09,75.53 133.99,74.43 133.99,72.57 134.56,72 134.56,70.1 133.76,69.3 133.76,59.68 146.79,46.65 146.79,45.14 148.19,43.74 148.19,43.25 147.86,42.92 147.86,42 147.76,41.9 147.41,41.9 147.04,41.53 147.04,41.03 147.41,40.66 147.71,40.66 148.05,40.32 148.05,39.71 147.79,39.44 147.65,39.44 147.46,39.64 v2(147.46,40.04)
  BOTTOM w0.114: v2(137.12,85.15) 137.21,85.15 U14.AK38 ; JDIM1.104 148.91,37.78 148.75,37.94 148.75,39.08 148.32,39.51 147.98,39.51 147.46,40.03 v2(147.46,40.04)
M_B_CLKP0: length 61.8
  IN1 w0.076: v2(137.12,83.2) 136.71,82.79 136.71,82.15 136.9,81.96 136.96,81.96 136.97,81.94
  IN1 w0.102: v2(148.89,41.35) 148.89,41.68 149.06,41.85 149.32,41.85 149.74,42.27 149.74,43.96 148.43,45.27 148.43,46.62 137.85,57.2 137.85,57.73 137.5,58.09 136.93,58.09 136.63,58.38 136.63,58.98 136.3,59.31 135.74,59.31 135.34,59.71 135.34,60.01 135.78,60.45 135.78,60.89 135.48,61.2 135.05,61.2 134.87,61.38 134.87,61.63 135.04,61.81 135.48,61.81 135.78,62.11 135.78,62.59 135.48,62.9 135.02,62.9 134.86,63.07 134.86,63.35 135.02,63.51 135.48,63.51 135.78,63.82 135.78,64.3 135.48,64.6 135,64.6 134.86,64.74 134.86,65.08 134.99,65.21 135.48,65.21 135.78,65.52 135.78,66 135.48,66.3 135.02,66.3 134.86,66.47 134.86,66.75 135.02,66.91 135.48,66.91 135.86,67.3 135.86,67.89 135.48,68.28 135,68.28 134.86,68.42 134.86,68.75 135,68.89 135.48,68.89 135.72,69.13 135.72,72.55 135.3,72.97 135.3,74.18 136.53,75.41 136.53,79.01 137.3,79.77 137.3,81.62 136.97,81.94
  BOTTOM w0.114: JDIM1.101 148.01,43.67 148.18,43.5 148.18,43.11 148.04,42.97 148.04,42.17 148.32,41.9 148.65,41.9 148.89,41.65 v2(148.89,41.35) ; U14.AN38 137.44,83.52 v2(137.12,83.2)
M_B_CLKP1: length 60.5
  IN1 w0.076: 136.3,81.77 136.3,81.79 136.27,81.83 136.27,84.56 136.47,84.76 136.86,84.76 v2(137.12,84.5)
  IN1 w0.102: 136.3,81.77 136.3,81.24 136.08,81.01 136.08,79.62 135.33,78.87 135.33,75.43 134.23,74.33 134.23,72.67 134.81,72.1 134.81,70 134.01,69.2 134.01,59.78 147.04,46.75 147.04,45.24 148.43,43.84 148.43,43.15 148.1,42.82 148.1,41.9 147.86,41.65 147.51,41.65 147.28,41.43 147.28,41.13 147.51,40.91 147.81,40.91 148.29,40.42 148.29,39.61 147.89,39.2 147.66,39.2 147.46,39 v2(147.46,38.77)
  BOTTOM w0.114: U14.AL38 137.51,84.63 137.38,84.5 v2(137.12,84.5) ; JDIM1.102 148.31,37.75 148.5,37.93 148.5,38.98 148.22,39.25 147.94,39.25 v2(147.46,38.77)
M_B_CS#0: length 61.5
  IN1 w0.14: v2(155.13,39.41) 155.13,41.16 154.21,42.07 154.21,44.23 154.73,44.75 154.73,48.46 139.51,63.69 139.51,73.21 140.29,74 140.29,76.9 141.51,78.12 142.22,78.12 143.72,79.61 143.72,80.51 143.32,80.91 141.69,80.91 141.31,81.29 141.31,82.28 141.49,82.46 141.49,83.29 v2(140.93,83.85)
  BOTTOM w0.165: U14.AM32 141.25,84.17 v2(140.93,83.85) ; v2(155.13,39.41) 155.1,39.43 153.37,39.43 151.91,37.97 JDIM1.114
M_B_CS#1: length 60.1
  IN1 w0.14: v2(140.9,85.15) 141.92,84.13 141.92,82.33 141.66,82.08 141.66,81.6 141.87,81.39 144.64,81.39 144.89,81.14 144.89,80.68 144.75,80.54 144.42,80.54 144.28,80.4 144.28,80.12 144.42,79.98 144.75,79.98 144.89,79.84 144.89,79.11 144.74,78.95 144.03,78.95 142.71,77.63 141.64,77.63 140.7,76.69 140.7,73.81 139.9,73.01 139.9,63.85 155.13,48.63 155.13,42.76 v2(154.8,42.43)
  BOTTOM w0.165: U14.AK32 140.99,85.15 v2(140.9,85.15) ; v2(154.8,42.43) 154.36,42.43 154.01,42.78 JDIM1.121
M_B_DQ0: length 55.8
  IN3 w0.114: v2(115.93,38.64) 116.91,38.64 118.15,39.89 118.15,40.59 118.3,40.74 118.3,46.98 120.28,48.96 120.28,57.06 130.56,67.34 130.56,71.16 135,75.6 136.2,75.6 136.71,76.11 137.27,76.11 v2(137.68,76.52)
  BOTTOM w0.076: U14.AY31 141.3,79.04 141.3,78.55 140.8,78.05 140,78.05 139.23,77.28 138.44,77.28 v2(137.68,76.52)
  BOTTOM w0.102: JDIM1.4 116.51,38.07 v2(115.93,38.64)
M_B_DQ1: length 56.5
  IN3 w0.114: v2(115.93,39.91) 116.24,39.91 117.91,41.58 117.91,47.14 119.89,49.12 119.89,57.22 130.04,67.37 130.04,71.2 134.96,76.11 136.13,76.11 136.51,76.49 136.99,76.49 v2(137.65,77.16)
  BOTTOM w0.076: v2(137.65,77.16) 137.98,77.48 139.15,77.48 139.89,78.22 140.73,78.22 141.13,78.62 141.13,78.93 141.08,78.99 141.08,79.18 141.1,79.23 141.17,79.36 141.37,79.56 U14.AW31
  BOTTOM w0.102: JDIM1.6 117.11,38.74 v2(115.93,39.91)
M_B_DQ2: length 55.7
  IN3 w0.114: v2(139.18,75.71) 138.98,75.71 136.91,73.65 136.91,72.43 136.79,72.3 135.36,72.3 135.23,72.17 135.23,71.77 135.43,71.58 136.04,71.58 136.23,71.39 136.23,71.01 136.04,70.82 135.43,70.82 135.23,70.63 135.23,69.84 125.28,59.89 125.28,59.62 125.75,59.15 125.75,58.88 125.48,58.61 125.21,58.61 124.74,59.08 124.47,59.08 124.2,58.81 124.2,58.54 124.67,58.07 124.67,57.8 124.4,57.53 124.14,57.53 123.66,58 123.4,58 123.17,57.77 123.17,57.5 123.64,57.03 123.64,56.76 123.37,56.49 123.1,56.49 122.63,56.96 122.36,56.96 122.06,56.66 122.06,56.3 122.44,55.92 122.44,55.54 121.85,54.95 121.85,48.37 119.81,46.33 119.81,43.17 v2(119.82,43.16)
  BOTTOM w0.076: U14.AY29 142.7,79.09 142.7,78.36 141.71,77.38 140.59,77.38 140.15,76.94 140.15,76.68 v2(139.18,75.71)
  BOTTOM w0.102: JDIM1.17 120.41,43.75 v2(119.82,43.16)
M_B_DQ3: length 57.2
  IN3 w0.114: v2(119.82,41.89) 119.89,41.89 120.28,42.28 120.28,45.96 122.25,47.92 122.25,54.78 126.51,59.04 126.51,59.31 126,59.81 126,59.99 126.36,60.35 126.54,60.35 127.04,59.85 127.31,59.85 127.64,60.17 127.64,60.44 127.17,60.91 127.17,61.18 127.44,61.45 127.71,61.45 128.18,60.98 128.44,60.98 128.71,61.25 128.71,61.52 128.24,61.99 128.24,62.26 128.51,62.53 128.78,62.53 129.25,62.06 129.52,62.06 129.8,62.34 129.8,62.65 129.32,63.13 129.32,63.37 137.32,71.37 137.32,73.29 139.07,75.04 139.15,75.04 v2(139.18,75.07)
  BOTTOM w0.076: v2(139.18,75.07) 140.32,76.21 140.32,76.87 140.66,77.21 141.78,77.21 142.88,78.32 142.88,78.86 143.01,78.99 143.01,79.23 142.72,79.52 U14.AW29
  BOTTOM w0.102: JDIM1.15 119.81,43.87 119.26,43.32 119.26,42.33 119.7,41.89 v2(119.82,41.89)
M_B_DQ4: length 57.6
  IN3 w0.114: v2(137.65,77.79) 137.27,77.79 136.03,76.54 134.83,76.54 129.65,71.36 129.65,67.54 119.5,57.39 119.5,49.28 118.48,48.27 117.15,48.27 116.82,47.93 116.82,45.92 117.52,45.23 117.52,41.75 117.19,41.43 116.39,41.43 116.26,41.55 116.26,41.92 116.39,42.05 v2(116.8,42.05)
  BOTTOM w0.076: U14.AV31 141.15,80.02 141.15,79.99 141.11,79.9 141.09,79.85 141.09,79.85 141.04,79.75 140.98,79.36 140.91,79.22 140.91,78.92 140.97,78.86 140.97,78.69 140.66,78.38 139.8,78.38 139.2,77.79 v2(137.65,77.79)
  BOTTOM w0.102: v2(116.8,42.05) 117.41,42.66 JDIM1.7
M_B_DQ5: length 57.6
  IN3 w0.114: v2(116.81,43.36) 117.12,43.67 117.12,45.07 116.43,45.76 116.43,48.1 117.79,49.46 118.06,49.46 118.45,49.07 118.72,49.07 118.99,49.34 118.99,49.61 118.6,50 118.6,50.27 119.1,50.77 119.1,57.55 119.76,58.21 119.76,58.48 119.47,58.78 119.47,59.05 119.74,59.32 120.01,59.32 120.3,59.02 120.57,59.02 120.84,59.29 120.84,59.56 120.55,59.85 120.55,60.12 120.82,60.39 121.09,60.39 121.38,60.1 121.65,60.1 121.98,60.43 121.98,60.7 121.84,60.84 121.84,61.11 122.11,61.38 122.38,61.38 122.52,61.24 122.79,61.24 123.06,61.51 123.06,61.78 122.92,61.92 122.92,62.19 123.19,62.46 123.46,62.46 123.6,62.32 123.87,62.32 129.25,67.7 129.25,71.52 135.03,77.3 135.03,77.68 135.77,78.42 v2(137.65,78.42)
  BOTTOM w0.076: U14.AU31 141.05,80.61 141.02,80.34 140.99,80.1 140.98,80.08 140.98,80.02 140.96,79.97 140.91,79.85 140.85,79.79 140.57,79.79 140.24,79.46 139.94,79.46 139.81,79.34 139.81,79.13 138.74,78.07 138.01,78.07 v2(137.65,78.42)
  BOTTOM w0.102: JDIM1.5 v2(116.81,43.36)
M_B_DQ6: length 57.4
  IN3 w0.114: v2(139.18,76.37) 139.68,75.86 139.68,74.33 139.25,73.9 139.04,73.9 138.17,73.03 138.17,71.11 135.09,68.03 135.09,67.7 135.57,67.22 135.57,66.99 135.26,66.68 134.99,66.68 134.53,67.15 134.26,67.15 133.99,66.88 133.99,66.61 134.46,66.15 134.46,65.88 134.17,65.59 133.9,65.59 133.77,65.71 133.5,65.71 133.23,65.44 133.23,65.17 133.36,65.05 133.36,64.78 123.04,54.46 123.04,47.6 121.07,45.63 121.07,39.58 v2(121.32,39.33)
  BOTTOM w0.076: U14.AV29 142.61,80.07 142.48,79.93 142.43,79.83 142.43,79.69 142.44,79.68 142.48,79.59 142.48,79.59 142.5,79.54 142.5,79.33 142.43,79.18 142.43,78.99 142.53,78.89 142.53,78.43 141.64,77.54 140.52,77.54 139.34,76.37 v2(139.18,76.37)
  BOTTOM w0.102: v2(121.32,39.33) 120.11,38.12 JDIM1.16
M_B_DQ7: length 58.9
  IN3 w0.114: v2(121.32,38.67) 120.68,39.31 120.68,45.8 122.64,47.76 122.64,54.62 130.47,62.44 130.47,62.71 129.98,63.19 129.98,63.46 130.25,63.73 130.52,63.73 131,63.25 131.27,63.25 131.54,63.52 131.54,63.79 131.06,64.27 131.06,64.54 131.33,64.81 131.6,64.81 132.08,64.33 132.35,64.33 132.67,64.65 132.67,64.96 132.19,65.44 132.19,65.68 137.75,71.24 137.75,73.17 139.02,74.44 v2(139.18,74.44)
  BOTTOM w0.076: U14.AU29 142.9,80.77 142.9,80.29 142.89,80.27 142.89,80.01 143.01,79.88 143.01,79.46 143.18,79.3 143.18,78.92 143.05,78.79 143.05,78.25 141.85,77.05 140.9,77.05 140.48,76.63 140.48,75.74 v2(139.18,74.44)
  BOTTOM w0.102: v2(121.32,38.67) 120.71,38.06 JDIM1.18
M_B_DQ8: length 53.3
  IN3 w0.114: v2(122.44,39.46) 122.45,39.44 123.76,39.44 123.88,39.57 123.88,39.94 123.76,40.07 123.35,40.07 123.23,40.19 123.23,44.72 124.92,46.41 124.92,53.64 140.27,68.99 140.27,72.49 140.85,73.07 140.85,73.49 140.7,73.65 140.7,74.79 v2(141.13,75.22)
  BOTTOM w0.076: v2(141.13,75.22) 141.54,75.63 141.54,75.98 143.55,77.99 143.55,78.59 143.67,78.71 143.67,78.98 U14.AY27
  BOTTOM w0.102: v2(122.44,39.46) 121.91,38.93 JDIM1.22
M_B_DQ9: length 53.8
  IN3 w0.114: v2(121.88,41.87) 121.88,40.58 122,40.45 122.18,40.45 122.44,40.7 122.44,45.04 124.13,46.73 124.13,53.97 139.33,69.17 139.33,72.81 140.17,73.65 140.17,75.6 141.05,76.49 v2(141.13,76.49)
  BOTTOM w0.076: U14.AW27 143.8,79.52 143.51,79.23 143.51,78.78 143.38,78.66 143.38,78.2 143.38,78.1 141.77,76.49 v2(141.13,76.49)
  BOTTOM w0.102: v2(121.88,41.87) 121.7,41.87 121.27,42.3 121.27,43.27 121.61,43.61 JDIM1.21
M_B_DQ10: length 52.9
  IN3 w0.076: v2(143.03,75.16) 142.45,74.58 142.45,72.99 142.25,72.79
  IN3 w0.114: 142.25,72.79 142.25,68.22 132.32,58.28 132.32,57.95 132.91,57.35 132.91,56.94 132.68,56.71 132.42,56.71 131.7,57.42 131.44,57.42 131.17,57.15 131.17,56.88 131.88,56.17 131.88,55.9 131.61,55.63 131.34,55.63 130.63,56.34 130.36,56.34 130.09,56.07 130.09,55.81 130.8,55.1 130.8,54.83 130.52,54.55 130.25,54.55 129.49,55.3 129.31,55.3 128.96,54.94 128.96,54.76 129.71,54.01 129.71,53.74 126.84,50.87 126.84,45.43 125.71,44.3 v2(125.71,43.32)
  BOTTOM w0.076: U14.AY25 145.02,78.98 145.02,77.99 143.66,76.63 143.66,75.79 v2(143.03,75.16)
  BOTTOM w0.102: v2(125.71,43.32) 125.81,43.42 JDIM1.35
M_B_DQ11: length 54.3
  IN3 w0.076: v2(143.03,74.54) 142.64,74.15 142.64,72.64 142.65,72.63
  IN3 w0.114: 142.65,72.63 142.65,68.03 133.31,58.69 133.31,56.78 128.55,52.02 128.55,51.08 128.35,50.89 127.57,50.89 127.44,50.76 127.44,50.12 127.57,49.99 128.34,49.99 128.53,49.8 128.53,49.42 128.34,49.23 127.43,49.23 127.24,49.04 127.24,45.26 126.21,44.23 126.21,41.17 124.95,39.91 v2(124.95,39.33)
  BOTTOM w0.076: v2(143.03,74.54) 143.83,75.33 143.83,76.56 145.19,77.92 145.19,78.73 145.44,78.98 145.44,79.18 145.39,79.28 145.39,79.28 145.37,79.33 145.37,79.54 U14.AW25
  BOTTOM w0.102: v2(124.95,39.33) 125.51,38.77 JDIM1.34
M_B_DQ12: length 54
  IN3 w0.114: v2(141.13,75.85) 141.13,75.83 140.38,75.08 140.38,73.25 139.78,72.66 139.78,69.07 124.52,53.8 124.52,46.57 122.83,44.88 122.83,40.54 121.95,39.66 121.95,38.54 v2(122.44,38.06)
  BOTTOM w0.076: v2(141.13,75.85) 141.13,75.83 140.74,76.23 140.74,76.65 140.97,76.88 141.92,76.88 143.21,78.18 143.21,78.72 143.34,78.85 143.34,79.31 143.51,79.47 143.51,79.88 143.9,80.28 U14.AV27
  BOTTOM w0.102: v2(122.44,38.06) 122.51,37.98 JDIM1.24
M_B_DQ13: length 55.2
  IN3 w0.076: v2(143.03,76.41) 142.54,76.9 140.88,76.9 139.88,75.91 139.88,73.92 139.64,73.68
  IN3 w0.114: v2(121.85,43.17) 121.85,45.01 123.73,46.9 123.73,54.17 136.63,67.06 136.63,67.33 136.15,67.81 136.15,68.08 136.42,68.35 136.69,68.35 137.17,67.87 137.44,67.87 137.71,68.14 137.71,68.41 137.23,68.89 137.23,69.16 137.5,69.43 137.77,69.43 138.25,68.95 138.52,68.95 138.87,69.3 138.87,72.91 139.64,73.68
  BOTTOM w0.076: U14.AU27 144.56,81.06 144.77,80.86 144.77,80.02 144.76,80 144.72,79.92 144.72,79.91 144.69,79.86 144.69,79.66 144.77,79.5 144.77,79.37 144.69,79.21 144.69,78.13 143.03,76.47 v2(143.03,76.41)
  BOTTOM w0.102: JDIM1.23 122.21,43.52 v2(121.85,43.17)
M_B_DQ14: length 54.7
  IN3 w0.076: 141.86,72.8 142.2,73.14 142.2,74.95 v2(143.03,75.78)
  IN3 w0.114: v2(125.71,42.05) 125.71,41.24 125.59,41.11 125.35,41.11 125.22,41.24 125.22,44.36 126.45,45.59 126.45,51.03 127.97,52.56 127.97,52.79 127.24,53.53 127.24,53.78 127.51,54.05 127.78,54.05 128.46,53.37 128.73,53.37 129,53.64 129,53.91 128.32,54.59 128.32,54.86 141.86,68.41 141.86,72.8
  BOTTOM w0.076: U14.AV25 145.04,80.3 145.04,80.06 144.91,79.93 144.86,79.83 144.86,79.69 144.87,79.68 144.91,79.59 144.93,79.54 144.93,79.33 144.86,79.18 144.86,78.06 143.5,76.7 143.5,76.24 v2(143.03,75.78)
  BOTTOM w0.102: JDIM1.33 125.21,42.55 v2(125.71,42.05)
M_B_DQ15: length 55.5
  IN3 w0.076: 143.04,73.39 143.04,73.91 v2(143.03,73.92)
  IN3 w0.114: v2(126.7,38.72) 126.45,38.47 126.11,38.47 125.78,38.8 125.78,39.02 126.04,39.28 126.04,39.56 125.78,39.82 125.78,40.03 126.6,40.85 126.6,44.07 127.63,45.1 127.63,48.53 127.76,48.65 128.81,48.65 128.94,48.78 128.94,51.85 134.25,57.16 134.25,57.62 133.71,58.15 133.71,58.48 143.05,67.81 143.05,71.7 143.04,71.71 143.04,73.39
  BOTTOM w0.076: U14.AU25 145.53,80.68 145.53,79.37 145.58,79.27 145.61,79.21 145.61,78.92 145.47,78.78 145.36,78.66 145.36,77.82 143.99,76.46 143.99,74.87 v2(143.03,73.92)
  BOTTOM w0.102: JDIM1.36 126.11,38.13 v2(126.7,38.72)
M_B_DQ16: length 58.6
  IN3 w0.076: 144.93,73.39 144.93,73.68 144.33,74.28 144.33,77.61 143.83,78.12 143.83,78.43 141.64,80.61 141.64,82.19 141.83,82.38 141.83,82.87 141.92,82.96 141.92,83.35 142.39,83.82 v2(142.39,83.85)
  IN3 w0.114: 144.93,73.39 144.93,67.03 139.71,61.81 139.71,61.35 140.24,60.82 140.24,60.5 130.82,51.07 130.82,46.19 128.09,43.45 128.09,41.17 129.22,40.04 v2(129.7,40.04)
  BOTTOM w0.102: JDIM1.42 127.91,38.25 v2(129.7,40.04)
  BOTTOM w0.165: U14.AM29 142.72,84.17 v2(142.39,83.85)
M_B_DQ17: length 60.4
  IN3 w0.076: 143.75,73.39 143.52,73.62 143.52,77.73 143.3,77.94 143.3,78.01 141.13,80.18 141.13,82.46 141.34,82.67 141.34,83.08 141.43,83.17 141.43,84.18 v2(142.39,85.15)
  IN3 w0.114: 143.75,73.39 143.75,67.52 134.95,58.72 134.95,56.87 129.64,51.56 129.64,48.49 128.33,47.18 128.33,44.81 127.3,43.78 127.3,40.62 128.15,39.76 128.15,39.58 127.9,39.33 127.72,39.33 127.06,39.99 v2(126.7,39.99)
  BOTTOM w0.102: v2(126.7,39.99) 127.31,39.38 JDIM1.40
  BOTTOM w0.165: v2(142.39,85.15) 142.72,85.47 U14.AK29
M_B_DQ18: length 59.1
  IN3 w0.076: v2(143.34,84.5) 142.74,84.5 142.67,84.43 142.14,84.43 141.76,84.04 141.76,83.03 141.67,82.94 141.67,82.46 141.48,82.27 141.48,80.5 143.66,78.31 143.66,78.05 144.05,77.66 144.05,74.15 144.53,73.67 144.53,73.39
  IN3 w0.114: 144.53,73.39 144.53,67.2 139.15,61.81 139.15,61.35 139.71,60.79 139.71,60.52 139.39,60.21 139.13,60.21 138.47,60.86 138.2,60.86 137.93,60.59 137.93,60.32 138.59,59.67 138.59,59.4 138.32,59.13 138.05,59.13 137.39,59.78 137.12,59.78 136.85,59.51 136.85,59.24 137.51,58.59 137.51,58.32 137.24,58.05 136.97,58.05 136.31,58.71 136.05,58.71 135.78,58.44 135.78,58.17 136.43,57.51 136.43,57.24 130.42,51.24 130.42,46.35 130.11,46.04 129.9,46.04 129.78,46.16 129.78,46.72 129.62,46.87 v2(129.24,46.87)
  BOTTOM w0.102: v2(129.24,46.87) 129.73,46.87 130.61,45.99 JDIM1.51
  BOTTOM w0.165: U14.AL28 143.67,84.82 v2(143.34,84.5)
M_B_DQ19: length 59.4
  IN3 w0.076: 144.14,73.39 144.14,73.56 143.73,73.96 143.73,77.75 143.47,78.01 143.47,78.2 141.3,80.37 141.3,82.35 141.5,82.55 141.5,83.01 141.59,83.1 141.59,84.11 142.07,84.6 142.61,84.6 143.16,85.15 v2(143.29,85.15)
  IN3 w0.114: 144.14,73.39 144.14,67.36 135.34,58.56 135.34,56.71 130.03,51.4 130.03,48.32 128.72,47.01 128.72,44.65 127.69,43.62 127.69,40.78 v2(129.7,38.77)
  BOTTOM w0.102: v2(129.7,38.77) 130.31,38.16 JDIM1.50
  BOTTOM w0.165: U14.AK28 143.62,85.47 v2(143.29,85.15)
M_B_DQ20: length 56.7
  IN3 w0.076: 145.72,73.39 145.72,78.06 143.95,79.82 143.11,79.82 142.2,80.73 v2(142.2,81.93)
  IN3 w0.114: v2(128.81,41.13) 128.81,41.01 129.24,40.58 129.7,40.58 129.82,40.7 129.82,40.96 129.32,41.46 129.32,41.97 129.65,42.3 129.65,43.9 131.61,45.86 131.61,50.75 143.12,62.26 143.12,63.99 145.72,66.59 145.72,73.39
  BOTTOM w0.102: v2(128.81,41.13) 127.01,42.94 JDIM1.39
  BOTTOM w0.165: U14.AR29 142.49,81.93 v2(142.2,81.93)
M_B_DQ21: length 57.8
  IN3 w0.076: 145.32,73.39 145.32,73.56 145.4,73.63 145.4,78.02 143.85,79.57 142.94,79.57 141.81,80.7 141.81,82.12 142,82.31 142,82.8 v2(142.39,83.2)
  IN3 w0.114: 145.32,73.39 145.32,66.75 142.32,63.76 142.32,63.54 142.72,63.14 142.72,62.8 142.5,62.57 142.31,62.57 141.81,63.06 141.55,63.06 141.28,62.79 141.28,62.52 141.92,61.88 141.92,61.61 141.65,61.34 141.38,61.34 140.74,61.98 140.47,61.98 140.2,61.71 140.2,61.45 140.84,60.8 140.84,60.54 131.22,50.92 131.22,46.03 129.26,44.07 129.26,42.48 129.18,42.4 v2(128.81,42.4)
  BOTTOM w0.102: JDIM1.41 127.61,43.61 v2(128.81,42.4)
  BOTTOM w0.165: U14.AN29 142.72,83.52 v2(142.39,83.2)
M_B_DQ22: length 55.9
  IN3 w0.076: v2(143.34,81.9) 143.34,81.59 146.2,78.74 147.06,78.74 147.35,78.44 147.35,74.39 147.72,74.03 147.72,73.39
  IN3 w0.114: 147.72,73.39 147.72,65.85 145.03,63.17 145.03,61.46 135.47,51.9 135.47,50.63 133.98,49.14 133.98,47.29 133.58,46.89 133.58,46.45 133.98,46.05 133.98,45.1 132.64,43.76 132.64,40.7 132.51,40.58 132.2,40.58 132.07,40.7 132.07,42.26 v2(132.14,42.33)
  BOTTOM w0.102: JDIM1.53 131.21,43.13 132.01,42.33 v2(132.14,42.33)
  BOTTOM w0.165: U14.AR28 143.67,82.22 v2(143.34,81.9)
M_B_DQ23: length 57
  IN3 w0.076: 147.32,73.39 147.32,73.7 147.1,73.93 147.1,78.35 146.9,78.55 146.02,78.55 142.95,81.62 142.95,82.06 143.34,82.45 v2(143.34,82.55)
  IN3 w0.114: 147.32,73.39 147.32,66.05 144.64,63.36 144.64,61.62 135.06,52.05 135.06,50.78 133.59,49.31 133.59,47.46 133.19,47.06 133.19,44.97 131.68,43.46 131.68,40.4 131.95,40.13 131.95,39.38 131.82,39.25 131.12,39.25 131,39.13 131,38.85 131.15,38.7 v2(131.5,38.7)
  BOTTOM w0.102: JDIM1.52 130.91,38.1 v2(131.5,38.7)
  BOTTOM w0.165: v2(143.34,82.55) 143.67,82.87 U14.AP28
M_B_DQ24: length 60
  IN3 w0.076: 148.73,79.23 147.63,79.23 147.36,79.51 147.06,79.51 144.84,81.73 144.84,83.04 144.69,83.2 v2(144.3,83.2)
  IN3 w0.114: 148.73,79.23 150.08,77.88 150.08,73.4 149.6,72.92 149.6,65.02 146.92,62.34 146.92,59.4 136.94,49.42 136.94,49.15 137.41,48.68 137.41,48.41 137.14,48.14 136.87,48.14 136.4,48.61 136.13,48.61 135.86,48.33 135.86,48.02 136.27,47.61 136.27,47.27 135.86,46.86 135.86,44.12 135.52,43.78 135.52,42.46 134.98,41.92 134.98,40.74 134.46,40.21 134.46,39.29 133.82,38.64 v2(133.31,38.64)
  BOTTOM w0.102: JDIM1.58 132.71,38.05 v2(133.31,38.64)
  BOTTOM w0.165: U14.AN26 144.62,83.52 v2(144.3,83.2)
M_B_DQ25: length 59.4
  IN3 w0.076: 148.37,78.83 148.17,79.03 147.54,79.03 147.28,79.29 146.9,79.29 v2(144.3,81.9)
  IN3 w0.114: v2(133.92,41.41) 133.92,41.11 134.04,40.98 134.46,40.98 134.59,41.11 134.59,42.09 135.12,42.62 135.12,44.04 135.47,44.39 135.47,48.53 143.13,56.19 143.13,56.46 142.77,56.83 142.77,57.1 143.04,57.37 143.31,57.37 143.67,57 143.94,57 144.19,57.25 144.19,57.52 143.83,57.89 143.83,58.16 144.1,58.43 144.37,58.43 144.73,58.06 145,58.06 145.27,58.33 145.27,58.6 144.91,58.97 144.91,59.24 145.18,59.51 145.45,59.51 145.81,59.14 146.08,59.14 146.35,59.41 146.35,59.68 145.98,60.04 145.98,60.26 146.52,60.79 146.52,62.51 149.2,65.2 149.2,74.08 149,74.28 149,78.19 148.37,78.83
  BOTTOM w0.102: JDIM1.57 132.41,43.81 132.64,43.58 132.64,42.69 v2(133.92,41.41)
  BOTTOM w0.165: U14.AR26 144.36,81.9 v2(144.3,81.9)
M_B_DQ26: length 58.1
  IN3 w0.076: v2(145.25,81.9) 145.5,81.9 145.7,81.7 145.7,81.35 147.18,79.87 147.36,79.87 147.72,79.51 149.03,79.51
  IN3 w0.114: 149.03,79.51 150.47,78.07 150.47,73.22 149.99,72.73 149.99,64.68 147.35,62.04 147.35,59.24 143.21,55.1 143.21,54.83 143.65,54.39 143.65,54.12 143.38,53.85 143.11,53.85 142.67,54.29 142.4,54.29 142.13,54.02 142.13,53.75 142.57,53.31 142.57,53.04 142.3,52.77 142.03,52.77 141.59,53.21 141.32,53.21 141.05,52.94 141.05,52.67 141.49,52.23 141.49,51.96 141.22,51.69 140.95,51.69 140.51,52.13 140.24,52.13 139.97,51.86 139.97,51.59 140.41,51.15 140.41,50.88 140.14,50.61 139.88,50.61 139.43,51.05 139.16,51.05 138.78,50.67 138.78,50.4 139.24,49.95 139.24,49.68 138.97,49.41 138.7,49.41 138.24,49.86 137.97,49.86 137.7,49.59 137.7,49.32 138.16,48.87 138.16,48.6 136.3,46.74 136.3,43.57 v2(136,43.27)
  BOTTOM w0.102: JDIM1.69 136.01,43.28 v2(136,43.27)
  BOTTOM w0.165: v2(145.25,81.9) 145.31,81.9 U14.AR25
M_B_DQ27: length 59.5
  IN3 w0.076: v2(145.25,82.55) 145.42,82.55 145.91,82.06 145.91,81.53 147.28,80.15 147.51,80.15 147.89,79.77 149.33,79.77
  IN3 w0.114: v2(136,42) 136,41.79 136.24,41.55 136.51,41.55 136.69,41.74 136.69,46.56 144.52,54.39 144.52,54.69 144.09,55.12 144.09,55.39 144.36,55.66 144.63,55.66 145.06,55.23 145.32,55.23 145.59,55.5 145.59,55.77 145.17,56.2 145.17,56.47 145.46,56.76 145.73,56.76 146.17,56.32 146.44,56.32 146.71,56.59 146.71,56.86 146.27,57.3 146.27,57.57 146.54,57.84 146.81,57.84 147.23,57.42 147.41,57.42 147.77,57.78 147.77,61.77 150.38,64.38 150.38,72.57 150.87,73.05 150.87,78.24 149.33,79.77
  BOTTOM w0.102: v2(136,42) 135.75,42 135.33,42.42 135.33,43.33 135.41,43.41 JDIM1.67
  BOTTOM w0.165: U14.AP25 145.31,82.55 v2(145.25,82.55)
M_B_DQ28: length 62
  IN3 w0.076: v2(144.24,85.15) 144.24,85 143.9,84.66 143.9,83.69 143.74,83.52 143.74,81.56 144.15,81.14 144.43,81.14 146.66,78.9 147.13,78.9 147.66,78.37 147.66,74.51 148.41,73.75 148.41,73.39
  IN3 w0.114: v2(133.31,39.91) 132.77,39.91 132.65,39.79 132.65,39.35 132.77,39.23 133.84,39.23 134.06,39.45 134.06,40.12 133.76,40.42 133.59,40.42 133.34,40.67 133.34,43.47 134.68,44.81 134.68,48.85 136.18,50.36 136.18,51.62 145.73,61.17 145.73,62.84 148.41,65.52 148.41,73.39
  BOTTOM w0.102: v2(133.31,39.91) 132.11,38.72 JDIM1.56
  BOTTOM w0.165: U14.AK26 144.57,85.47 v2(144.24,85.15)
M_B_DQ29: length 61
  IN3 w0.076: v2(144.3,83.85) 143.9,83.45 143.9,81.63 144.08,81.44 144.41,81.44 146.75,79.11 147.23,79.11 147.68,78.65
  IN3 w0.114: v2(133.92,42.68) 133.92,42.56 134.09,42.38 134.33,42.38 134.73,42.78 134.73,44.21 135.07,44.55 135.07,48.69 136.92,50.53 136.92,50.8 136.58,51.14 136.58,51.41 136.85,51.68 137.11,51.68 137.45,51.34 137.72,51.34 137.99,51.61 137.99,51.88 137.65,52.22 137.65,52.49 137.92,52.76 138.19,52.76 138.53,52.42 138.8,52.42 139.16,52.77 139.16,53.04 138.79,53.41 138.79,53.68 139.06,53.95 139.33,53.95 139.7,53.58 139.96,53.58 140.23,53.85 140.23,54.12 139.87,54.49 139.87,54.76 140.14,55.03 140.41,55.03 140.77,54.66 141.04,54.66 141.31,54.93 141.31,55.2 140.95,55.56 140.95,55.83 141.22,56.1 141.49,56.1 141.85,55.74 142.12,55.74 142.39,56.01 142.39,56.28 142.03,56.64 142.03,56.91 145.98,60.87 146.12,61.01 146.12,62.67 148.81,65.36 148.81,73.92 148.65,74.08 148.65,78.01 148.01,78.65 147.68,78.65
  BOTTOM w0.102: v2(133.92,42.68) 133.71,42.68 133.01,43.39 JDIM1.59
  BOTTOM w0.165: v2(144.3,83.85) 144.36,83.85 U14.AM26
M_B_DQ30: length 61.9
  IN3 w0.076: v2(145.2,85.15) 145.36,85.15 145.81,84.7 145.81,84.19 145.93,84.06 146.67,84.06 146.87,84.27 147.25,84.27 147.51,84.01 147.51,81.7 147.79,81.42 150.5,81.42 151.14,80.78
  IN3 w0.114: v2(136.91,38.72) 137.09,38.89 137.11,38.89 138.64,40.43 138.64,45.78 149.7,56.84 149.7,60.86 152.29,63.44 152.29,68.39 152.79,68.9 152.79,79.13 151.14,80.78
  BOTTOM w0.102: JDIM1.70 136.31,38.12 v2(136.91,38.72)
  BOTTOM w0.165: v2(145.2,85.15) 145.52,85.47 U14.AK25
M_B_DQ31: length 61.7
  IN3 w0.076: v2(145.25,84.5) 145.54,84.5 145.64,84.39 145.64,84.12 145.87,83.9 146.25,83.9 146.62,83.53 146.62,81.75 147.15,81.22 150.15,81.22 150.86,80.5
  IN3 w0.114: 150.86,80.5 152.4,78.97 152.4,72.45 151.89,71.94 151.89,71.53 152.08,71.34 152.19,71.34 152.38,71.15 152.38,70.77 152.19,70.58 152.08,70.58 151.89,70.39 151.89,70.01 152.08,69.82 152.19,69.82 152.38,69.63 152.38,69.25 152.19,69.06 152.08,69.06 151.89,68.87 151.89,63.67 149.31,61.09 149.31,57.01 138.2,45.9 138.2,40.95 137.24,39.99 v2(136.91,39.99)
  BOTTOM w0.102: v2(136.91,39.99) 136.15,39.23 136.15,38.57 135.71,38.13 JDIM1.68
  BOTTOM w0.165: U14.AL25 145.57,84.82 v2(145.25,84.5)
M_B_DQ32: length 52.1
  IN1 w0.089: v2(144.94,75.58) 144.05,74.69 144.05,73.6 143.47,73.01 142.83,73.01 142.4,72.58 142.4,72.25 141.94,71.79 141.94,65.02 146.06,60.91 146.06,60.17 155.18,51.05 157.07,49.16 157.07,41.45 158.5,40.02 158.5,39.43 v2(157.89,38.82)
  BOTTOM w0.076: v2(144.94,75.58) 145.89,76.53 145.89,78.32 146.5,78.93 U14.AY23
  BOTTOM w0.102: v2(157.89,38.82) 157.31,38.24 JDIM1.132
M_B_DQ33: length 53.3
  IN1 w0.089: v2(144.94,76.21) 143.85,75.12 143.85,73.67 143.37,73.19 142.68,73.19 141.51,72.02 141.51,64.93 145.65,60.79 145.65,60.03 155.18,50.51 156.73,48.96 156.73,41.24 157.59,40.37 157.59,39.38 157.36,39.15 v2(156.75,39.15)
  BOTTOM w0.076: U14.AW23 146.32,79.4 146.21,79.18 146.21,79.06 146.17,78.95 146.11,78.83 145.69,78.4 145.69,76.96 v2(144.94,76.21)
  BOTTOM w0.102: v2(156.75,39.15) 156.53,38.93 156.52,38.93 156.26,38.67 156.26,38.31 156.27,38.3 156.27,38.29 156.71,37.85 JDIM1.130
M_B_DQ34: length 52
  IN1 w0.076: v2(146.67,76.14) 145.7,75.17 145.7,74.08 144.13,72.5
  IN1 w0.089: 144.13,72.5 143.93,72.31 143.93,65.69 147.99,61.63 147.99,60.86 158.92,49.94 158.92,46.92 159.23,46.61 159.23,43.38 159.7,42.91 159.7,40.47 159.83,40.35 160.1,40.35 160.23,40.47 160.23,41.95 v2(160.18,42)
  BOTTOM w0.076: U14.AY21 147.85,78.42 147.42,77.99 147.42,77.69 147.23,77.5 147.23,76.69 v2(146.67,76.14)
  BOTTOM w0.102: JDIM1.143 160.61,42.43 v2(160.18,42)
M_B_DQ35: length 53.2
  IN1 w0.076: 144.27,72.22 144.55,72.5 144.55,72.69 145.87,74 145.87,74.7 v2(146.67,75.5)
  IN1 w0.089: 144.27,72.22 144.27,65.83 148.37,61.74 148.37,60.97 159.26,50.08 159.26,49.39 159.4,49.25 160.04,49.25 160.18,49.11 160.18,48.83 160.04,48.69 159.4,48.69 159.26,48.55 159.26,48.27 159.41,48.12 160.14,48.12 160.28,47.98 160.28,47.7 160.14,47.56 159.42,47.56 159.29,47.44 159.29,47.13 159.42,47 160.14,47 160.28,46.86 160.28,46.58 160.14,46.44 159.71,46.44 159.57,46.3 159.57,46.03 159.71,45.89 160.14,45.89 160.28,45.75 160.28,45.47 160.14,45.33 159.71,45.33 159.57,45.19 159.57,44.91 159.71,44.77 160.14,44.77 160.28,44.63 160.28,44.35 160.14,44.21 159.71,44.21 159.57,44.07 159.57,43.85 159.7,43.72 160.03,43.72 160.16,43.6 v2(160.16,43.29)
  BOTTOM w0.076: U14.AW21 148.14,79.47 148.14,78.99 148.02,78.86 148.02,78.35 147.58,77.92 147.58,77.62 147.39,77.43 147.39,76.22 v2(146.67,75.5)
  BOTTOM w0.102: v2(160.16,43.29) 160.01,43.44 JDIM1.141
M_B_DQ36: length 53.6
  IN1 w0.089: v2(144.94,76.85) 143.52,75.42 143.52,73.72 143.21,73.42 142.68,73.42 142.53,73.57 142.53,74.36 142.43,74.46 142.15,74.46 141.99,74.31 141.99,73.42 141.17,72.59 141.17,64.79 141.42,64.54 141.42,64.45 141.17,64.2 141.17,64.06 141.4,63.83 141.57,63.83 141.74,64 141.94,64 142.14,63.8 142.14,63.6 141.97,63.43 141.97,63.24 142.17,63.04 142.36,63.04 142.53,63.21 142.73,63.21 142.93,63.01 142.93,62.81 142.76,62.64 142.76,62.44 142.95,62.24 143.15,62.24 143.32,62.42 143.52,62.42 143.72,62.22 143.72,62.02 143.55,61.85 143.55,61.65 143.74,61.45 143.94,61.45 144.11,61.63 144.31,61.63 144.51,61.43 144.51,61.23 144.34,61.06 144.34,60.86 144.53,60.66 144.73,60.66 144.9,60.84 145.1,60.84 145.3,60.64 145.3,60.44 145.13,60.27 145.13,60.07 145.92,59.28 155.18,50.02 156.38,48.81 156.38,43.41 v2(156.22,43.24)
  BOTTOM w0.076: U14.AV23 146.43,80.1 146.21,79.88 146.11,79.35 146.04,79.22 146.04,79.21 145.98,79.07 145.68,78.7 145.52,78.54 145.52,77.43 v2(144.94,76.85)
  BOTTOM w0.102: JDIM1.129 156.41,43.43 v2(156.22,43.24)
M_B_DQ37: length 54.9
  IN1 w0.089: v2(156.22,41.9) 155.94,41.9 155.79,42.04 155.79,43.65 156.04,43.9 156.04,48.67 155.18,49.54 140.83,63.89 140.83,72.73 141.64,73.54 141.64,75.78 142.76,76.9 144.03,76.9 144.55,77.42 v2(146.67,77.42)
  BOTTOM w0.076: U14.AU23 147.26,81.06 147.47,80.86 147.47,80.61 147.41,80.55 147.41,80.45 147.45,80.41 147.45,80.29 147.47,80.27 147.47,80.02 147.46,80 147.42,79.92 147.42,79.91 147.39,79.86 147.39,79.66 147.47,79.5 147.47,79.37 147.42,79.27 147.39,79.21 147.39,78.43 147.09,78.12 147.09,77.83 146.68,77.42 v2(146.67,77.42)
  BOTTOM w0.102: v2(156.22,41.9) 156.45,41.9 157.01,42.46 JDIM1.131
M_B_DQ38: length 53.1
  IN1 w0.089: v2(146.67,76.77) 145.5,75.6 145.5,74.23 143.59,72.32 143.59,65.55 147.61,61.53 147.61,60.76 158.57,49.79 158.57,46.75 158.89,46.44 158.89,43.24 159.36,42.77 159.36,38.58 159.88,38.06 v2(160.56,38.06)
  BOTTOM w0.076: U14.AV21 147.75,80.07 147.61,79.93 147.56,79.83 147.56,79.69 147.57,79.68 147.61,79.59 147.63,79.54 147.63,79.33 147.56,79.18 147.56,78.36 147.25,78.05 147.25,77.76 147.06,77.57 147.06,77.16 v2(146.67,76.77)
  BOTTOM w0.102: v2(160.56,38.06) 160.31,37.81 JDIM1.142
M_B_DQ39: length 54.8
  IN1 w0.076: v2(146.67,74.84) 146.03,74.2 146.03,73.92 144.81,72.7 144.81,72.45 144.62,72.25
  IN1 w0.089: 144.62,72.25 144.62,65.97 148.73,61.87 148.73,61.1 160.64,49.19 160.64,40.12 160.51,39.99 159.83,39.99 159.7,39.86 159.7,39.46 159.8,39.36 v2(160.54,39.36)
  BOTTOM w0.076: v2(146.67,74.84) 147.58,75.75 147.58,76.98 147.75,77.14 147.75,77.85 148.18,78.28 148.18,78.79 148.31,78.92 148.31,79.72 148.01,80.01 148.01,80.22 148.06,80.55 148.06,80.74 U14.AU21
  BOTTOM w0.102: v2(160.54,39.36) 160.51,39.36 159.71,38.56 JDIM1.140
M_B_DQ40: length 52.2
  IN1 w0.076: v2(148.14,76.74) 147.23,75.83 147.23,73.93 146.88,73.58 146.39,73.58 145.61,72.8 145.61,72.5
  IN1 w0.089: 145.61,72.5 145.61,66.38 150.69,61.3 150.69,60.91 155.05,56.55 155.44,56.55 161.82,50.17 161.82,44.06 162.3,43.59 162.3,40.93 162.17,40.8 161.55,40.8 161.43,40.93 v2(161.43,41.44)
  BOTTOM w0.076: U14.AY19 148.93,78.84 148.7,78.61 148.7,77.3 v2(148.14,76.74)
  BOTTOM w0.102: JDIM1.149 162.41,42.42 v2(161.43,41.44)
M_B_DQ41: length 53.2
  IN1 w0.076: 145.95,72.5 145.95,72.83 146.52,73.39 146.95,73.39 147.39,73.84 147.39,75.34 v2(148.16,76.11)
  IN1 w0.089: 145.95,72.5 145.95,66.53 151.04,61.44 151.04,61.07 155.17,56.93 155.54,56.93 162.16,50.31 162.16,44.2 162.64,43.73 162.64,40.04 162.28,39.69 v2(161.83,39.69)
  BOTTOM w0.076: v2(148.16,76.11) 147.75,76.52 147.75,76.91 148.13,77.29 148.3,77.29 148.53,77.52 148.53,78.68 148.64,78.78 148.64,79.47 U14.AW19
  BOTTOM w0.102: v2(161.83,39.69) 161.83,39.71 162.37,39.18 162.37,38.09 162.11,37.83 JDIM1.148
M_B_DQ42: length 51.7
  IN1 w0.076: v2(149.5,75.73) 148.75,74.98 148.75,74.38 148.22,73.84 148.22,72.59 148.13,72.5
  IN1 w0.089: v2(165.49,42.07) 166.1,41.46 166.1,40.91 166,40.8 165.15,40.8 164.82,41.13 164.82,46.58 164.39,47.01 164.39,51.22 148.13,67.48 148.13,72.5
  BOTTOM w0.076: U14.AY17 150.2,79.03 150.2,78.85 150.2,76.43 v2(149.5,75.73)
  BOTTOM w0.102: v2(165.49,42.07) 164.81,42.75 JDIM1.157
M_B_DQ43: length 52.1
  IN1 w0.076: 148.55,72.5 148.55,73.94 148.92,74.31 148.92,74.9 149.11,75.1 v2(149.52,75.1)
  IN1 w0.089: v2(165.41,43.39) 165.41,43.39 165.31,43.39 165.18,43.27 165.18,42.73 165.28,42.64 165.49,42.64 165.77,42.91 166,42.91 166.13,43.04 166.13,43.26 165.92,43.47 165.92,43.88 166.13,44.09 166.13,44.36 166.02,44.46 165.83,44.46 165.58,44.22 165.38,44.22 165.18,44.41 165.18,44.61 165.43,44.86 165.43,45.06 165.25,45.23 165.25,46.93 165.11,47.07 164.89,47.07 164.75,47.21 164.75,47.49 164.89,47.63 165.11,47.63 165.25,47.77 165.25,48.05 165.11,48.19 164.89,48.19 164.75,48.33 164.75,48.6 164.89,48.74 165.11,48.74 165.25,48.88 165.25,49.16 165.11,49.3 164.89,49.3 164.75,49.44 164.75,49.67 164.88,49.8 165.13,49.8 165.25,49.92 165.25,50.18 165.13,50.3 164.87,50.3 164.74,50.43 164.74,50.62 165.03,50.91 165.03,51.13 148.55,67.62 148.55,72.5
  BOTTOM w0.076: U14.AW17 150.57,79.18 150.57,78.99 150.36,78.78 150.36,78.64 150.36,78.64 150.36,76.3 150.08,76.02 150.08,75.67 v2(149.52,75.1)
  BOTTOM w0.102: JDIM1.159 165.41,43.4 v2(165.41,43.39)
M_B_DQ44: length 53.6
  IN1 w0.076: 145.26,72.5 145.26,72.7 146.31,73.75 146.79,73.75 147.06,74.01 147.06,76.61 v2(148.14,77.68)
  IN1 w0.089: v2(161.43,42.71) 161.29,42.57 161.29,41.97 161.39,41.87 161.84,41.87 161.95,41.98 161.95,43.44 161.48,43.92 161.48,49.62 161.23,49.86 161.23,50.22 161.02,50.43 160.66,50.43 160.44,50.65 160.44,51.01 160.22,51.22 159.87,51.22 159.65,51.44 159.65,51.8 159.43,52.02 159.08,52.02 158.86,52.23 158.86,52.59 158.64,52.81 158.29,52.81 158.07,53.02 158.07,53.38 157.85,53.6 157.5,53.6 157.28,53.81 157.28,54.17 157.06,54.39 156.71,54.39 156.49,54.6 156.49,54.96 156.27,55.18 155.92,55.18 155.7,55.39 155.7,55.75 155.48,55.97 155.13,55.97 151.29,59.8 150.96,59.8 150.16,60.6 150.16,60.8 150.33,60.97 150.33,61.17 150.14,61.36 149.94,61.36 149.77,61.19 149.57,61.19 149.37,61.39 149.37,62.13 145.26,66.24 145.26,72.5
  BOTTOM w0.076: U14.AV19 149.04,80.28 148.47,79.72 148.47,78.85 148.35,78.72 148.35,77.89 v2(148.14,77.68)
  BOTTOM w0.102: JDIM1.147 161.81,43.6 161.86,43.55 161.86,43.15 v2(161.43,42.71)
M_B_DQ45: length 54.6
  IN1 w0.076: v2(149.5,77) 148.76,76.26 148.76,76.15 148.33,75.72 148.08,75.72 147.56,75.2 147.56,73.77 146.29,72.5
  IN1 w0.089: v2(161.88,38.39) 162.47,38.98 162.47,39.33 162.98,39.84 162.98,43.87 162.52,44.33 162.52,50.44 155.65,57.31 155.28,57.31 151.38,61.21 151.38,61.58 146.29,66.67 146.29,72.5
  BOTTOM w0.076: v2(149.5,77) 149.87,77.37 149.87,77.78 149.83,77.83 149.83,79.21 149.9,79.37 149.9,79.5 149.83,79.66 149.83,79.86 149.85,79.91 149.85,79.92 149.89,80 149.9,80.02 149.9,80.86 149.7,81.06 U14.AU19
  BOTTOM w0.102: v2(161.88,38.39) 161.88,38.01 161.51,37.64 JDIM1.146
M_B_DQ46: length 53
  IN1 w0.076: v2(149.52,76.38) 148.57,75.44 148.57,74.43 148.05,73.91 148.05,73.43 147.79,73.16 147.79,72.5
  IN1 w0.089: 147.79,72.5 147.79,67.29 148.41,66.67 164.05,51.03 164.05,46.87 164.48,46.44 164.48,40.54 164.79,40.23 165.35,40.23 v2(165.49,40.37)
  BOTTOM w0.076: U14.AV17 150.28,80.17 150.04,79.93 149.99,79.83 149.99,79.69 150,79.68 150.04,79.59 150.06,79.54 150.06,79.33 149.99,79.18 149.99,77.9 150.03,77.85 150.03,76.9 v2(149.52,76.38)
  BOTTOM w0.102: JDIM1.158 165.11,39.99 v2(165.49,40.37)
M_B_DQ47: length 53.9
  IN1 w0.089: v2(149.52,74.44) 148.89,73.81 148.89,67.76 165.6,51.05 165.6,45.38 166.47,44.5 166.47,40.67 165.57,39.76 165.57,38.9 165.79,38.67 v2(166.3,38.67)
  BOTTOM w0.076: U14.AU17 150.57,80.77 150.57,80.02 150.66,79.38 150.74,79.22 150.74,78.92 150.53,78.71 150.53,76.21 150.25,75.93 150.25,75.17 v2(149.52,74.44)
  BOTTOM w0.102: JDIM1.160 165.71,38.08 v2(166.3,38.67)
M_B_DQ48: length 56.4
  IN1 w0.076: 151.79,76.1 151.6,76.29 151.6,78.09 148,81.69 v2(148,81.9)
  IN1 w0.089: 151.79,76.1 152.14,75.74 152.14,73.64 152.43,73.36 152.43,69.43 161.33,60.54 161.52,60.54 161.66,60.67 161.85,60.67 162.05,60.47 162.05,60.27 161.92,60.14 161.92,59.94 162.12,59.75 162.31,59.75 162.45,59.88 162.64,59.88 162.84,59.68 162.84,59.48 162.71,59.35 162.71,59.15 170.32,51.55 170.32,45.15 170.09,44.92 170.09,44.49 170.32,44.26 170.32,44 170.19,43.88 169.78,43.88 169.65,44 169.65,46.12 v2(169.55,46.21)
  BOTTOM w0.102: JDIM1.165 167.21,46.19 167.87,46.85 168.92,46.85 v2(169.55,46.21)
  BOTTOM w0.165: U14.AR21 148.32,82.22 v2(148,81.9)
M_B_DQ49: length 57.3
  IN1 w0.076: 151.14,76.57 151.09,76.62 151.09,78.11 148.04,81.16 147.78,81.16 v2(147.05,81.9)
  IN1 w0.089: v2(168.43,47.36) 168.43,46.88 168.61,46.7 168.94,46.7 169.25,47 169.4,47 169.58,47.18 169.58,47.66 169.4,47.84 168.59,47.84 168.44,48 168.44,48.22 168.59,48.38 169.45,48.38 169.63,48.56 169.63,48.76 169.45,48.94 168.61,48.94 168.43,49.12 168.43,49.32 168.61,49.5 169.45,49.5 169.63,49.68 169.63,49.88 169.45,50.06 168.61,50.06 168.43,50.24 168.43,50.44 168.61,50.62 169.45,50.62 169.63,50.8 169.63,51.16 169.3,51.49 169.11,51.49 168.84,51.22 168.61,51.22 168.45,51.38 168.45,51.62 168.71,51.88 168.71,52.08 151.74,69.05 151.74,73.04 151.44,73.34 151.44,75.58 151.14,75.88 151.14,76.57
  BOTTOM w0.102: JDIM1.163 166.61,46.34 167.62,47.36 v2(168.43,47.36)
  BOTTOM w0.165: v2(147.05,81.9) 147.37,82.22 U14.AR22
M_B_DQ50: length 59.7
  IN1 w0.076: 150.47,76.31 150.47,77.66 149.13,79.01 148.54,79.01 146.26,81.29 146.26,82.18 146.77,82.69 147.09,82.69 147.44,83.03 147.44,83.94 v2(148,84.5)
  IN1 w0.089: 150.47,76.31 150.47,74.15 150.22,73.9 150.22,68.36 166.93,51.66 166.93,45.93 167.81,45.05 167.81,40.98 v2(169.43,39.36)
  BOTTOM w0.102: JDIM1.174 169.91,37.65 169.43,38.14 v2(169.43,39.36)
  BOTTOM w0.165: U14.AL21 148.32,84.82 v2(148,84.5)
M_B_DQ51: length 59.6
  IN1 w0.076: 149.54,72.5 149.54,73.8 149.92,74.18 149.92,77.75 149.58,78.09 148.9,78.09 145.91,81.09 145.91,82.29 146.65,83.04 146.65,83.45 v2(147.05,83.85)
  IN1 w0.089: 149.54,72.5 149.54,68.08 166.25,51.37 166.25,45.65 167.12,44.77 167.12,40.45 169.38,38.19 v2(170.11,38.19)
  BOTTOM w0.102: v2(170.11,38.19) 170.51,37.79 JDIM1.176
  BOTTOM w0.165: U14.AM22 147.11,83.85 v2(147.05,83.85)
M_B_DQ52: length 58.3
  IN1 w0.076: v2(147.05,83.2) 146.08,82.23 146.08,81.19 148.98,78.29 149.61,78.29 150.31,77.6 150.31,77.38 150.1,77.17 150.1,76.92 150.31,76.71 150.31,76.52 150.12,76.34 150.12,74.15 149.88,73.91 149.88,72.5
  IN1 w0.089: v2(168.26,39.91) 167.46,40.71 167.46,44.91 166.59,45.79 166.59,51.51 149.88,68.22 149.88,72.5
  BOTTOM w0.102: v2(168.26,39.91) 168,39.91 166.91,38.82 JDIM1.164
  BOTTOM w0.165: U14.AN22 147.37,83.52 v2(147.05,83.2)
M_B_DQ53: length 57.7
  IN1 w0.076: 151.29,76.82 151.25,76.86 151.25,78.2 147.98,81.47 147.76,81.47 147.6,81.62 147.6,82.15 v2(148,82.55)
  IN1 w0.089: v2(169.64,40.83) 169.64,43.22 169.31,43.55 169.31,45.67 169.12,45.86 169.12,46.39 169.4,46.67 169.77,46.67 169.97,46.87 169.97,51.3 152.08,69.19 152.08,73.21 151.8,73.5 151.8,75.6 151.39,76.01 151.39,76.72 151.29,76.82
  BOTTOM w0.102: JDIM1.166 167.51,38.32 169.64,40.45 v2(169.64,40.83)
  BOTTOM w0.165: v2(148,82.55) 148.32,82.87 U14.AP21
M_B_DQ54: length 59.7
  IN1 w0.076: 152.06,76.31 151.85,76.52 151.85,78.09 148.39,81.55 148.39,84.73 v2(147.97,85.15)
  IN1 w0.089: 152.06,76.31 152.48,75.89 152.48,73.78 152.77,73.5 152.77,69.58 153.87,68.48 154.55,68.48 154.76,68.26 154.76,68.07 154.62,67.93 154.62,67.73 154.82,67.53 155.02,67.53 155.16,67.67 155.36,67.67 155.55,67.47 155.55,67.27 155.41,67.13 155.41,66.94 155.61,66.74 155.81,66.74 155.95,66.88 156.15,66.88 156.34,66.68 156.34,66.48 156.2,66.34 156.2,66.15 156.4,65.95 156.6,65.95 156.74,66.09 156.94,66.09 157.13,65.89 157.13,65.69 156.99,65.55 156.99,65.36 157.19,65.16 157.39,65.16 157.53,65.3 157.73,65.3 157.92,65.1 157.92,64.9 157.78,64.76 157.78,64.57 157.98,64.37 158.18,64.37 158.32,64.51 158.52,64.51 158.71,64.31 158.71,64.11 158.57,63.97 158.57,63.78 158.77,63.58 158.97,63.58 159.11,63.72 159.31,63.72 159.5,63.52 159.5,63.32 159.36,63.18 159.36,62.98 159.56,62.79 159.76,62.79 159.9,62.93 160.1,62.93 160.3,62.73 160.3,62.53 160.16,62.39 160.16,62.19 160.35,62 160.55,62 160.69,62.14 160.89,62.14 161.09,61.94 161.09,61.74 160.95,61.6 160.95,61.4 161.14,61.21 161.34,61.21 161.48,61.35 161.68,61.35 163.43,59.59 163.43,59.45 163.23,59.24 163.23,59.12 170.66,51.69 170.66,43.57 170.45,43.37 v2(170.21,43.37)
  BOTTOM w0.102: JDIM1.175 170.21,43.37 v2(170.21,43.37)
  BOTTOM w0.165: v2(147.97,85.15) 148.3,85.47 U14.AK21
M_B_DQ55: length 60.6
  IN1 w0.076: v2(147.05,85.15) 147.17,85.15 147.56,85.54 148.14,85.54 148.37,85.31 148.37,85.29 148.56,85.1 148.56,81.64 152.08,78.11 152.08,77
  IN1 w0.089: v2(170.21,42) 170.06,41.84 170.06,41.31 170.18,41.18 170.5,41.18 170.65,41.33 170.65,43.08 171,43.43 171,51.83 163.9,58.93 163.9,59.69 154.77,68.82 154.06,68.82 153.18,69.7 153.18,73.61 152.83,73.96 152.83,76.07 152.08,76.82 152.08,77
  BOTTOM w0.102: JDIM1.177 170.81,42.59 v2(170.21,42)
  BOTTOM w0.165: U14.AK22 147.37,85.47 v2(147.05,85.15)
M_B_DQ56: length 61.9
  IN1 w0.076: v2(148.95,83.2) 149.34,82.8 149.34,81.36 152.47,78.23 152.47,77.36 153.16,76.68 153.26,76.68
  IN1 w0.089: 153.26,76.68 154.17,75.77 154.17,70.84 164.98,60.03 164.98,59.25 171.99,52.24 171.99,43.02 171.63,42.66 171.63,40.5 171.32,40.19 170.59,40.19 170.47,40.07 170.47,39.53 170.62,39.38 171.2,39.38 171.48,39.66 171.99,39.66 172.12,39.79 v2(172.12,41.13)
  BOTTOM w0.102: JDIM1.183 172.61,41.63 v2(172.12,41.13)
  BOTTOM w0.165: v2(148.95,83.2) 149.28,83.52 U14.AN20
M_B_DQ57: length 60.6
  IN1 w0.076: v2(148.95,81.9) 148.95,81.5 152.31,78.14 152.31,77.15 153.02,76.44
  IN1 w0.089: v2(171.71,39.2) 171.71,37.78 171.59,37.65 170.82,37.65 170.7,37.78 170.7,38.7 170.11,39.28 170.11,40.33 170.32,40.54 171.18,40.54 171.27,40.63 171.27,42.79 171.65,43.16 171.65,52.1 164.6,59.15 164.6,59.93 153.83,70.7 153.83,74.46 153.81,74.46 153.48,74.79 153.48,75.98 153.02,76.44
  BOTTOM w0.102: v2(171.71,39.2) 171.71,39.2 JDIM1.180
  BOTTOM w0.165: U14.AR20 149.28,82.22 v2(148.95,81.9)
M_B_DQ58: length 62.8
  IN1 w0.076: v2(149.81,85.28) 149.97,85.28 150.47,84.78 150.47,84.4 151.14,83.73 151.14,82.21 151.51,81.84 152.04,81.84 154.41,79.46 155.11,79.46 155.76,78.8
  IN1 w0.089: v2(175.42,38.49) 175.13,38.78 175.13,39.27 175.36,39.5 175.56,39.5 175.89,39.16 176.09,39.16 176.29,39.36 176.29,39.56 175.95,39.89 175.95,40.09 176.28,40.41 176.28,44.27 176.09,44.45 176.09,53.58 159.15,70.53 159.15,72.42 157.61,73.96 157.61,76.96 155.76,78.8
  BOTTOM w0.102: JDIM1.192 175.31,38.38 v2(175.42,38.49)
  BOTTOM w0.165: U14.AK18 150.01,85.47 v2(149.81,85.28)
M_B_DQ59: length 62.4
  IN1 w0.076: v2(149.84,84.49) 149.85,84.5 149.9,84.5 150.81,83.59 150.81,81.81 151.43,81.19 152.07,81.19 154.22,79.04 154.55,79.04 155.18,78.41 155.19,78.41
  IN1 w0.089: 155.19,78.41 156.92,76.67 156.92,73.68 157.39,73.21 157.39,73.01 156.81,72.44 156.81,72.24 157.01,72.04 157.21,72.04 157.78,72.62 157.98,72.62 158.47,72.13 158.47,70.22 175.37,53.31 175.37,44.08 175.59,43.86 175.59,41.31 175.37,41.08 v2(175.01,41.08)
  BOTTOM w0.102: JDIM1.194 175.91,40.19 v2(175.01,41.08)
  BOTTOM w0.165: U14.AL18 149.97,84.5 149.85,84.5 v2(149.84,84.49)
M_B_DQ60: length 63.5
  IN1 w0.076: v2(148.95,85.15) 149.21,84.89 150.01,84.89 150.24,84.66 150.24,84.4 150.97,83.66 150.97,82.02 151.62,81.37 152.13,81.37 154.21,79.28 154.8,79.28 155.52,78.56
  IN1 w0.089: 155.52,78.56 157.27,76.82 157.27,73.82 158.81,72.27 158.81,70.37 175.75,53.43 175.75,44.31 175.94,44.13 175.94,40.56 174.05,38.67 v2(172.91,38.67)
  BOTTOM w0.102: v2(172.91,38.67) 172.31,38.07 JDIM1.182
  BOTTOM w0.165: v2(148.95,85.15) 149.28,85.47 U14.AK20
M_B_DQ61: length 62.1
  IN1 w0.076: 153.5,76.93 153.42,77.01 153.09,77.01 152.81,77.29 152.81,78.19 149.51,81.5 149.51,82.87 149.35,83.03 149.35,83.44 v2(148.95,83.85)
  IN1 w0.089: 153.5,76.93 154.52,75.91 154.52,71.06 165.54,60.04 165.54,59.84 165.33,59.63 165.33,59.43 165.53,59.23 165.72,59.23 165.93,59.44 166.13,59.44 166.33,59.24 166.33,59.05 166.12,58.84 166.12,58.64 166.32,58.44 166.51,58.44 166.72,58.65 166.92,58.65 167.12,58.45 167.12,58.26 166.91,58.05 166.91,57.85 167.11,57.65 167.3,57.65 167.51,57.86 167.71,57.86 167.91,57.66 167.91,57.47 167.7,57.26 167.7,57.06 167.9,56.86 168.09,56.86 168.3,57.07 168.5,57.07 168.7,56.87 168.7,56.68 168.49,56.47 168.49,56.27 168.69,56.07 168.88,56.07 169.09,56.28 169.29,56.28 169.49,56.08 169.49,55.89 169.28,55.68 169.28,55.48 169.48,55.28 169.68,55.28 169.88,55.49 170.08,55.49 170.28,55.29 170.28,55.1 170.07,54.89 170.07,54.69 170.27,54.49 170.47,54.49 170.67,54.7 170.87,54.7 171.07,54.5 171.07,54.3 170.86,54.1 170.86,53.86 171.1,53.62 171.3,53.62 171.51,53.83 171.71,53.83 171.91,53.64 171.91,53.44 171.69,53.22 171.69,53.02 172.33,52.38 172.33,44.44 172.6,44.18 172.6,43.72 172.33,43.46 172.33,43.1 172.6,42.84 172.6,42.33 172.47,42.2 172.22,42.2 172.09,42.33 v2(172.09,42.45)
  BOTTOM w0.102: JDIM1.181 172.01,42.54 v2(172.09,42.45)
  BOTTOM w0.165: U14.AM20 149.02,83.85 v2(148.95,83.85)
