# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
5V_LGATE1 on TOP (solid shape): 134.39,26.61 134.99,26.61 135.11,26.49 135.69,26.49 135.9,26.28 135.9,25.99 135.47,25.56 134.9,25.56 134.78,25.67 134.12,25.67 133.32,26.47 133.22,26.47 133.06,26.64 133.06,26.94 133.09,26.97 134.03,26.97
5V_LGATE1 on BOTTOM (solid shape): 138.01,23.62 138.01,23.3 137.91,23.2 137.52,23.2 137.24,22.92 137.24,22.72 137.2,22.68 136.47,22.68 136.46,22.69 136.46,23.18 137.02,23.74 137.88,23.74
5V_PHASE1 on TOP (solid shape): 134.61,27.3 135.88,27.3 136.03,27.45 136.84,27.45 136.92,27.38 136.92,26.84 136.79,26.72 135.37,26.72 135.22,26.87 134.58,26.87 134.25,27.2 133.07,27.2 133.03,27.23 133.03,27.45 133.05,27.48 134.43,27.48
5V_PHASE1 on BOTTOM (solid shape): 140.73,24.66 140.73,24.25 141.72,23.26 143.42,23.26 144.12,22.56 144.12,17.59 143.72,17.19 139.58,17.19 139.43,17.34 139.43,19.15 137.85,20.72 137.85,23.02 137.93,23.1 138.21,23.1 138.34,23.23 138.34,23.67 138.54,23.87 139.36,23.87 139.56,24.07 139.56,24.74 139.66,24.84 140.55,24.84
5V_UGATE1 on TOP (solid shape): 135.8,27.96 135.8,27.66 135.7,27.55 134.68,27.55 134.53,27.7 133.06,27.7 133.03,27.74 133.03,27.96 133.05,27.98 134.72,27.98 134.83,28.09 135.67,28.09
5V_UGATE1 on BOTTOM (solid shape): 142.02,16.68 142.02,16.18 141.84,16 139.94,16 139.45,16.48 139.45,16.85 139.47,16.86 141.84,16.86
+1.1V_DSP on TOP (solid shape): 264.42,40.73 264.6,40.73 267.09,38.24 267.09,38.21 268.44,38.21 268.54,38.31 268.54,38.8 268.54,38.8 268.54,39.77 268.56,39.79 268.74,39.79 268.74,38.8 268.94,38.8 268.94,39.79 269.05,39.79 269.12,39.71 269.12,37.53 268.46,36.87 268.46,36.59 268.28,36.41 266.91,36.41 266.91,36.44 264.85,38.49 264.5,38.49 263.25,39.74 263.25,41.13 263.38,41.26 263.89,41.26
+1.1V_DSP on TOP (solid shape): 250.68,42.89 250.68,42.45 251.04,42.1 252.15,42.1 252.36,42.3 252.63,42.3 252.84,42.51 252.84,42.79 253.04,42.99 255.48,42.99 255.79,42.68 255.79,41.87 255.51,41.59 255.51,41.34 255.2,41.03 253.96,41.03 253.55,40.63 250.3,40.63 250.17,40.75 250.17,41.01 249.92,41.26 249.92,41.29 249.18,42.02 252.74,42.02 252.74,41.97 252.75,41.92 252.77,41.87 252.8,41.82 252.83,41.78 252.87,41.74 252.92,41.71 252.96,41.69 253.01,41.68 253.07,41.67 253.12,41.67 253.17,41.68 253.22,41.69 253.27,41.71 253.32,41.74 253.36,41.78 253.39,41.82 253.42,41.87 253.43,41.92 253.45,41.97 253.45,42.02 253.45,42.08 253.43,42.13 253.42,42.18 253.39,42.22 253.36,42.27 253.32,42.3 253.27,42.33 253.22,42.36 253.17,42.37 253.12,42.38 253.07,42.38 253.01,42.37 252.96,42.36 252.92,42.33 252.87,42.3 252.83,42.27 252.8,42.22 252.77,42.18 252.75,42.13 252.74,42.08 252.74,42.02 249.18,42.02 248.65,42.56 247.1,42.56 247.07,42.58 247.07,42.91 247.2,43.04 250.53,43.04
+1.1V_DSP on BOTTOM (solid shape): outline of 213 points within 254.08,35.06 269.03,43.29
+1.05V_GFX on TOP (solid shape): 211.41,119.14 211.41,116.83 211.34,116.75 209.48,116.75 209.33,116.9 209.33,119.16 209.46,119.29 211.26,119.29
+1.05V_GFX on TOP (solid shape): 175.7,94.12 175.7,93.38 176.26,92.82 176.26,92.01 176.21,91.96 174.71,91.96 174.63,92.04 174.63,93.89 174.99,94.25 175.57,94.25
+1.05V_GFX on TOP (solid shape): outline of 760 points within 189.34,98.64 204.55,114.69
+1.05V_GFX on BOTTOM (solid shape): 178.29,103.36 178.29,102.73 177.53,101.97 177.02,101.97 176.61,102.37 176.61,103.03 177.27,103.69 177.96,103.69
+1.05V_GFX on BOTTOM (solid shape): 176.69,94.09 176.69,93.81 175.78,92.9 175.01,92.9 174.76,93.15 174.76,94.22 174.89,94.35 175.26,94.35 175.4,94.32 175.53,94.35 175.65,94.43 175.73,94.54 175.81,94.63 176.16,94.63
+1.05V_GFX on BOTTOM (solid shape): outline of 1309 points within 194.19,99.63 204.68,115.61
+1.05V_GFX on IN1 (solid shape): 197.67,106.49 197.67,105.55 197.49,105.37 196.88,105.37 195.94,106.31 195.87,106.39 195.87,107.1 196.02,107.25 196.91,107.25
+1.05V_GFX on IN1 (solid shape): 177.94,103.59 178.32,103.59 178.9,103.01 179.28,103.01 179.36,102.93 179.36,102.04 179.15,101.84 178.72,101.84 177.33,103.23 177.33,103.59 177.44,103.7 177.46,103.7 177.59,103.7 177.71,103.75 177.78,103.75
+1.05V_GFX on IN3 (solid shape): outline of 226 points within 200.03,101.41 211.08,118.43
+1.05V_RUN on TOP (solid shape): 152.54,111.34 152.54,110.1 152.38,109.94 150.94,109.94 150.88,109.99 150.88,111.42 150.94,111.47 152.41,111.47
+1.5V_RUN on TOP (solid shape): 161.6,112.41 161.6,111.8 161.53,111.72 159.19,111.72 158.78,112.13 158.78,112.36 159.19,112.76 161.25,112.76
+1.5V_RUN on TOP (solid shape): 308.03,80.91 308.03,80.55 307.65,80.17 306.61,80.17 306.48,80.3 306.48,80.53 306.92,80.96 307.98,80.96
+1.5V_RUN on TOP (solid shape): 278.11,45.96 278.11,44.51 277.63,44.03 277.35,44.03 277.31,44.07 277.31,45.97 277.55,46.21 277.86,46.21
+1.5V_RUN on TOP (solid shape): 307.96,85.38 307.96,84.42 307.93,84.42 307.91,84.39 306.99,84.39 306.79,84.59 306.79,85.61 306.94,85.76 307.58,85.76
+1.05V_RUN on TOP (solid shape): 151.29,87.64 151.29,87.08 151.39,86.98 151.67,86.98 151.87,86.78 151.87,86.57 151.65,86.35 149.97,86.35 149.72,86.6 149.72,87.62 149.82,87.72 151.21,87.72
+1.05V_RUN on TOP (solid shape): 156.02,88.35 156.02,87.18 155.81,86.98 154.9,86.98 154.85,87.03 154.85,87.46 154.87,87.49 155.35,87.49 155.51,87.64 155.51,88.43 155.58,88.51 155.86,88.51
+1.05V_RUN on TOP (solid shape): 263,41.26 263,40.5 262.75,40.25 262.11,40.25 261.98,40.12 261.22,40.12 260.33,41.01 260.33,41.26 260.46,41.39 262.87,41.39
+1.5V_RUN on TOP (solid shape): 313.04,85.97 313.04,85.08 313.34,84.77 313.34,84.2 313.16,84.02 312.28,84.02 312.28,84.16 313.02,84.16 313.02,84.36 312.28,84.36 312.28,85.84 312.53,86.09 312.91,86.09
+1.05V_RUN on TOP (solid shape): 146.64,88.45 146.64,88.02 146.95,87.72 148.04,87.72 148.34,87.41 148.34,86.93 148.22,86.8 146.67,86.8 146.26,87.21 145.8,87.21 145.65,87.36 145.65,88.53 145.68,88.56 146.54,88.56
+1.5V_RUN on TOP (solid shape): 161.53,122.52 161.53,120.15 161.18,119.81 157.15,119.81 156.37,119.04 156.37,116.65 156.02,116.29 153.78,116.29 153.63,116.45 153.63,116.93 153.91,117.21 153.91,119.77 157.36,123.23 160.82,123.23
+1.05V_RUN on TOP (solid shape): 180.88,116.04 180.88,114.36 179.66,113.14 175.78,113.14 175.15,113.77 175.15,113.94 175,114.1 175,114.73 174.81,114.92 174.81,115.84 174.93,115.96 176.39,115.96 176.52,115.83 176.52,115.1 176.7,114.92 178.42,114.92 179.31,115.81 179.56,115.81 179.95,116.2 180.72,116.2
+1.5V_RUN on TOP (solid shape): 252.76,49.72 252.76,45.09 252.65,44.83 252.76,44.57 252.76,44.31 253.06,44.02 253.06,43.46 252.9,43.31 251.53,43.31 251.19,43.65 251.19,49.64 251.39,49.85 252.64,49.85
+1.05V_RUN on TOP (solid shape): 152.15,97.67 152.15,97.4 152,97.24 151.32,97.24 151.04,96.96 151.04,96.51 150.78,96.25 150.25,96.25 150.12,96.13 150.12,95.97 149.97,95.82 148.4,95.82 148.32,95.85 148.29,95.93 147.91,96.3 147.59,95.88 147.46,95.74 147.46,94.25 147.86,93.84 148.12,93.84 148.34,93.61 148.34,92.87 148.45,92.77 149.21,92.77 149.28,92.7 149.28,91.98 149.18,91.88 149.18,91.5 149.28,91.4 149.28,90.72 149.28,90.71 149.26,90.69 148.6,90.69 148.57,90.71 148.57,90.95 148.42,91.1 148.42,91.43 147.71,92.14 147.71,93.2 147.48,93.43 146.26,93.43 146.13,93.56 146.13,95.31 146.49,95.67 146.49,96.71 146.72,96.94 148.65,96.94 149.13,96.46 149.77,96.46 149.97,96.66 149.97,96.68 151.09,97.8 152.03,97.8
+1.5V_RUN on BOTTOM (solid shape): 161.02,124.65 161.63,124.65 161.76,124.52 161.76,123.56 161.43,123.23 161.43,120.31 161.12,120 158.2,120 158.05,120.15 158.05,124.41 158.34,124.7 160.97,124.7
+1.05V_RUN on BOTTOM (solid shape): 152.64,111.09 152.64,109.97 152.5,109.83 152.44,109.78 152.39,109.72 152.28,109.61 152.28,109.46 152.21,109.38 150.12,109.38 150.05,109.46 150.05,110.42 150.1,110.47 150.93,110.47 151.65,111.19 152.54,111.19
+1.05V_RUN on BOTTOM (solid shape): 156.02,88.38 156.02,88.12 155.84,87.95 155.84,87.69 156.04,87.49 156.04,87.21 155.81,86.98 155.81,86.78 155.71,86.68 155.48,86.68 154.92,87.24 154.92,87.49 155.15,87.72 155.15,87.84 154.87,88.12 154.87,88.38 154.93,88.44 155.68,88.44 155.74,88.51 155.89,88.51
+1.05V_RUN on BOTTOM (solid shape): 170.07,117.94 170.05,117.88 170.04,117.83 170.03,117.78 170.04,117.72 170.06,117.67 170.08,117.62 170.11,117.58 170.14,117.54 170.18,117.5 170.23,117.47 170.28,117.45 170.34,117.44 170.34,116.17 170.04,115.87 165.64,115.87 165.08,116.42 165.08,116.85 167.44,116.85 167.44,116.8 167.45,116.75 167.47,116.7 167.49,116.65 167.52,116.6 167.56,116.56 167.6,116.53 167.65,116.5 167.7,116.49 167.75,116.47 167.8,116.47 167.85,116.47 167.91,116.49 167.96,116.5 168,116.53 168.04,116.56 168.08,116.6 168.11,116.65 168.13,116.7 168.15,116.75 168.16,116.8 168.16,116.85 168.15,116.91 168.13,116.96 168.11,117 168.08,117.05 168.04,117.09 168,117.12 167.96,117.15 167.91,117.17 167.85,117.18 167.8,117.18 167.75,117.18 167.7,117.17 167.65,117.15 167.6,117.12 167.56,117.09 167.52,117.05 167.49,117 167.47,116.96 167.45,116.91 167.44,116.85 165.08,116.85 165.08,117.99 165.29,118.2 169.81,118.2
+1.5V_RUN on BOTTOM (solid shape): outline of 204 points within 310.7,73.29 315.4,79.56
+1.05V_RUN on IN1 (solid shape): outline of 323 points within 167.95,112.36 180.97,118.35
+1.05V_RUN on SVCC (solid shape): outline of 417 points within 147.3,86.47 197.85,121.52
+1.5V_RUN on IN2 (solid shape): 161.62,112.59 161.62,111.26 161.36,111 160.12,111 160,111.11 160,111.85 160.79,112.64 161.58,112.64
+1.5V_RUN on IN2 (solid shape): 252.69,49.8 252.69,49.41 252.54,49.26 251.32,49.26 251.24,49.34 251.24,49.87 251.34,49.97 252.51,49.97
+1.5V_RUN on IN2 (solid shape): 313.98,74.15 313.98,72.63 313.65,72.3 312.76,72.3 312.5,72.55 312.5,73.39 313.37,74.26 313.88,74.26
+1.5V_RUN on IN2 (solid shape): 170.42,88.43 170.42,87.14 170.4,87.13 170.36,87.09 170.33,87.04 170.3,86.99 170.29,86.94 170.28,86.89 170.28,86.83 170.28,86.8 170.28,86.78 170.28,86.72 170.29,86.67 170.3,86.61 170.33,86.57 170.36,86.52 170.4,86.48 170.42,86.46 170.42,85.97 170.14,85.69 169.27,85.69 169.05,85.91 169.05,86.42 168.73,86.74 168.69,86.81 168.69,87.73 169.41,87.73 169.42,87.68 169.43,87.62 169.45,87.57 169.48,87.53 169.52,87.49 169.56,87.45 169.6,87.42 169.65,87.4 169.7,87.38 169.76,87.37 169.81,87.37 169.86,87.38 169.91,87.4 169.96,87.42 170.01,87.45 170.05,87.49 170.08,87.53 170.11,87.57 170.13,87.62 170.15,87.68 170.15,87.73 170.15,87.78 170.14,87.84 170.12,87.89 170.1,87.94 170.07,87.98 170.03,88.02 169.99,88.05 169.94,88.08 169.89,88.1 169.84,88.11 169.78,88.11 169.73,88.11 169.68,88.1 169.63,88.08 169.58,88.05 169.54,88.02 169.5,87.98 169.47,87.94 169.44,87.89 169.42,87.84 169.41,87.78 169.41,87.73 168.69,87.73 168.69,88.56 168.79,88.66 170.19,88.66
+1.05V_RUN on IN2 (solid shape): outline of 296 points within 145.68,85.86 151.85,93.59
+1.5V_RUN on IN2 (solid shape): outline of 348 points within 277.1,44.03 290.1,51.01
+1.5V_RUN on IN2 (solid shape): outline of 621 points within 150.4,96.62 156.04,117.82
+1.05V_SUS on TOP (solid shape): 175.8,96.2 175.8,95.29 175.7,95.19 175.34,95.19 175.27,95.11 175.22,95.11 174.96,94.86 174.96,94.47 174.38,93.89 174.38,92.06 173.95,91.63 172.96,91.63 172.83,91.76 172.83,92.21 172.98,92.37 172.98,93.71 173.52,94.25 173.52,94.27 173.72,94.47 173.72,95.33 173.72,95.34 173.72,96.38 173.74,96.4 173.95,96.45 174.12,96.58 175.42,96.58
+1.05V_SUS on TOP (solid shape): 179.84,120.15 179.84,118.3 179.56,118.02 178.67,118.02 177.24,116.59 174.71,116.59 174.49,116.37 173.01,116.37 172.93,116.4 172.9,116.48 172.91,116.55 172.91,116.85 172.84,117.09 172.66,117.26 172.65,117.26 172.47,117.44 171.36,117.44 170.8,117.99 170.8,120.49 171.02,120.71 179.28,120.71
+1.05V_SUS on BOTTOM (solid shape): 176.26,97.5 176.26,95.59 175.93,95.26 174.94,95.26 174.76,95.44 174.76,96.43 175.07,96.73 175.07,97.42 175.45,97.8 175.95,97.8
+1.05V_SUS on BOTTOM (solid shape): 197.94,114.19 197.94,108.95 197.64,108.65 193.63,108.65 193.25,109.03 193.25,109.94 192.85,110.35 192.06,110.35 191.91,110.5 191.91,113.47 191.98,113.55 192.69,113.55 193.71,114.57 197.56,114.57
+1.05V_SUS on BOTTOM (solid shape): 179.43,125.34 179.43,122.8 179.69,122.54 182.91,122.54 185.38,125 188.65,125 189.06,124.6 189.06,118.81 188.4,118.15 181.01,118.15 180.93,118.07 173.67,118.07 173.49,118.25 173.49,123.96 174.07,124.55 176.06,124.55 176.39,124.88 176.39,125.72 176.51,125.84 178.93,125.84
+1.05V_SUS on BOTTOM (solid shape): 178.21,106.53 178.21,106.05 177.86,105.7 177.34,105.7 177.05,105.85 176.75,105.7 176.46,105.41 176.46,104.63 176.31,104.48 174.84,104.48 174.68,104.63 174.68,106.46 174.83,106.61 178.03,106.61 178.05,106.63 178.11,106.63
+1.05V_SUS on IN1 (solid shape): outline of 173 points within 173.34,110.93 194.94,121.04
+1.05V_SUS on IN2 (solid shape): 178.09,107.2 178.09,106.08 177.99,105.98 176.94,105.98 176.36,106.56 176.36,107.58 176.79,108.01 177.27,108.01
+1.05V_SUS on IN2 (solid shape): 179.89,119.24 179.89,119.04 178.51,117.65 178.15,117.65 177.94,117.44 177.94,117.08 177.74,116.89 175.64,116.89 174.48,118.05 173.95,118.05 173.69,118.3 173.69,119.87 174.02,120.2 178.93,120.2
+1.05V_SUS on IN2 (solid shape): outline of 438 points within 147.46,94.8 151.54,101.54
+1.05V_SUS on IN2 (solid shape): outline of 980 points within 153.16,85.43 168.46,89.35
+1.05V_SUS on IN3 (solid shape): 174.18,92.18 174.18,91.74 174.14,91.73 173.93,91.56 173.89,91.3 173.9,91.27 173.85,91.22 172.68,91.22 172.27,90.82 172.25,90.82 172.03,90.78 171.87,90.62 171.83,90.51 171.83,90.4 171.83,90.38 169.24,87.78 167.69,87.78 167.5,87.59 167.29,87.59 167.13,87.75 167.13,87.88 170.89,91.64 170.89,91.72 171.17,92 171.59,92 172.08,92.49 173.86,92.49
+1.35V_GFX on TOP (solid shape): 198.26,88.53 198.26,88.2 198.48,87.97 198.86,87.97 199.09,87.74 199.09,87.57 198.97,87.44 196.22,87.44 195.97,87.69 195.97,88.3 196.3,88.63 198.15,88.63
+1.35V_GFX on TOP (solid shape): 211.56,104.63 211.56,103.69 211.36,103.49 210.75,103.49 210.57,103.31 210.57,103.03 210.42,102.88 210.14,102.88 209.96,103.06 209.96,104.74 210.07,104.84 211.36,104.84
+1.35V_GFX on TOP (solid shape): 199.45,97.24 199.45,95.57 199.4,95.52 198.97,95.52 198.92,95.57 198.92,95.97 198.69,96.2 198.46,96.2 198.31,96.35 198.31,96.68 198.2,96.79 197.9,96.79 197.85,96.84 197.85,97.22 197.9,97.27 199.42,97.27
+1.35V_GFX on TOP (solid shape): 194.72,88.71 194.95,88.71 195,88.66 195,87.57 194.88,87.44 194.8,87.44 194.8,87.44 193.26,87.44 193.21,87.38 192.77,87.38 192.59,87.56 192.59,88.66 192.7,88.66 192.77,88.73 193.27,88.73 193.35,88.66 193.81,88.66 193.94,88.78 194.64,88.78
+1.35V_GFX on TOP (solid shape): 225.19,109.73 225.19,107.8 225.03,107.63 223.12,107.63 221.98,106.49 221.34,106.49 221.32,106.46 221.09,106.46 221.01,106.54 221.01,106.77 221.12,106.87 221.12,107.22 220.91,107.43 220.91,108.29 221.06,108.44 222.03,108.44 223.4,109.82 225.1,109.82
+1.35V_GFX on TOP (solid shape): 229.83,79.03 230.08,78.29 230.77,76.47 232.11,73.42 232.11,71.84 232.04,71.77 230.21,71.77 229.84,71.4 228.74,71.4 228.58,71.56 228.58,72.12 228.25,72.45 226.3,72.45 226.2,72.55 226.2,73.6 226.14,73.65 226.14,75.22 226.32,75.4 227.08,75.4 227.26,75.58 227.26,77.02 227.44,77.2 227.44,78.22 227.16,78.5 226.93,78.5 226.8,78.62 226.8,78.93 226.96,79.08 227.34,79.08 227.67,79.41 227.67,79.51 227.85,79.69 229.57,79.69
+1.35V_GFX on TOP (solid shape): 199.88,91.78 200.13,91.78 200.14,91.75 200.49,91.5 200.82,91.77 200.83,91.79 201.13,92.09 201.35,92.09 201.66,91.78 201.66,91.15 201.43,90.92 200.36,90.92 199.96,90.51 199.96,90.08 199.8,89.93 198.74,89.93 198.51,90.16 198.51,90.99 198.51,91 198.54,91.12 198.51,91.25 198.51,91.26 198.51,91.35 198.48,91.35 198.48,92.05 198.61,92.18 199.49,92.18
+1.35V_GFX on BOTTOM (solid shape): 229.68,79.16 230.03,78.4 230.03,77.48 230.59,76.92 230.59,75.88 231.35,75.12 231.35,74.18 232.06,73.47 232.06,72.55 231.91,72.4 228.23,72.4 227.62,73.01 226.68,73.01 226.4,73.29 226.4,74.26 226.55,74.41 227.26,74.41 227.39,74.54 227.39,77.1 227.52,77.23 227.52,78.35 227.39,78.47 227.01,78.47 226.8,78.68 226.8,79.01 226.93,79.13 227.49,79.13 227.77,79.41 229.52,79.41
+1.35V_GFX on BOTTOM (solid shape): outline of 103 points within 192.39,87.08 200.21,98.21
+1.35V_GFX on IN1 (solid shape): outline of 2033 points within 191.93,87.34 199.96,99.5
+1.35V_GFX on SVCC (solid shape): outline of 111 points within 191.63,69.13 230.74,114.03
+3.3V_ALW on TOP (solid shape): 281.54,42.07 281.54,40.02 281.36,39.84 280.65,39.84 280.02,40.47 280.02,40.88 279.84,41.06 279.59,41.06 279.36,41.29 279.36,42.66 279.71,43.01 280.6,43.01
+3.3V_ALW on TOP (solid shape): 230.21,35.98 230.21,35.24 230.13,35.17 229.37,35.17 229.22,35.32 229.22,35.52 228.91,35.83 227.85,35.83 227.64,35.62 227.64,35.09 227.54,34.99 227.54,34.4 227.26,34.12 226.17,34.12 226.12,34.17 226.12,35.27 226.47,35.62 226.47,36 226.68,36.21 229.98,36.21
+3.3V_ALW on TOP (solid shape): 86.57,29.12 86.57,28.08 86.47,27.98 86.47,27.11 86.14,26.78 83.57,26.78 82.66,27.7 81.9,27.7 81.75,27.85 81.75,28.35 85.6,28.35 85.6,28.59 84.61,28.59 84.61,28.35 83,28.35 83,28.59 82.01,28.59 82.01,28.35 81.75,28.35 81.75,29.04 81.97,29.27 86.42,29.27
+3.3V_ALW on TOP (solid shape): 223.2,119.39 223.2,117.41 223.53,117.08 224.49,117.08 224.72,116.85 224.72,115.48 224.6,115.35 223.43,115.35 223.15,115.07 221.32,115.07 221.18,115.21 221.18,116.12 222.1,116.12 222.1,116.91 221.79,116.91 221.79,116.12 221.18,116.12 221.18,118.52 222.1,118.52 222.1,119.31 221.79,119.31 221.79,118.52 221.18,118.52 221.18,119.48 221.29,119.59 222.99,119.59
+3.3V_ALW on TOP (solid shape): 214.46,36 214.46,35.65 214.13,35.32 213.42,35.32 213.04,34.94 213.04,33.8 213.29,33.55 213.29,31.25 213.04,31 207.86,31 207.25,31.61 207.25,33.56 207.78,34.1 210.37,34.1 210.37,32.63 210.88,32.12 212.25,32.12 212.35,32.22 212.35,33.08 212,33.44 212,35.22 211.86,35.35 211.87,35.36 211.87,35.64 212.05,35.82 212.05,35.9 212.35,36.21 214.26,36.21
+3.3V_ALW on TOP (solid shape): 192.62,39.66 192.62,38.09 192.39,37.86 192.39,35.9 191.41,35.9 191.41,35.63 192.39,35.63 192.39,35.11 192.24,34.96 188.58,34.96 188.45,35.09 188.45,35.65 189.81,35.65 189.81,35.89 188.81,35.89 188.81,35.65 188.45,35.65 188.45,39.02 192.41,39.02 192.41,39.25 191.41,39.25 191.41,39.02 189.81,39.02 189.81,39.25 188.81,39.25 188.81,39.02 188.45,39.02 188.45,39.53 188.84,39.92 192.36,39.92
+3.3V_ALW on BOTTOM (solid shape): 280.63,44.08 280.63,42.05 280.35,41.77 279.28,41.77 278.8,42.25 278.8,43.39 278.49,43.7 278.49,44.28 278.52,44.31 280.4,44.31
+3.3V_ALW on BOTTOM (solid shape): 113.85,31.51 115.27,31.51 115.94,30.84 115.94,29.67 115.82,29.67 115.82,29.08 115.94,29.08 115.94,25.33 114.13,23.52 114.13,17.93 109.42,17.93 109.08,18.27 109.08,21.58 109.33,21.83 109.33,25.01 109.71,25.39 109.71,26.99 109.15,27.55 109.15,27.57 108.59,28.13 108.59,33.36 108.86,33.63 111.73,33.63
+3.3V_ALW on BOTTOM (solid shape): 251.31,48.88 252.13,48.88 252.54,48.47 252.54,47.08 252.4,46.94 250.34,46.94 250.17,47.1 249.66,47.1 249.51,46.95 249.51,46.54 249.44,46.47 247.03,46.47 246.62,46.88 246.62,48.19 248.64,48.19 248.65,48.14 248.66,48.09 248.68,48.04 248.7,47.99 248.74,47.95 248.78,47.91 248.82,47.88 248.87,47.86 248.92,47.84 248.97,47.84 249.03,47.84 249.08,47.84 249.13,47.86 249.18,47.88 249.22,47.91 249.26,47.95 249.29,47.99 249.32,48.04 249.34,48.09 249.35,48.14 249.36,48.19 249.35,48.25 249.34,48.3 249.32,48.35 249.29,48.39 249.26,48.44 249.22,48.47 249.18,48.5 249.13,48.52 249.08,48.54 249.03,48.55 248.97,48.55 248.92,48.54 248.87,48.52 248.82,48.5 248.78,48.47 248.74,48.44 248.7,48.39 248.68,48.35 248.66,48.3 248.65,48.25 248.64,48.19 246.62,48.19 246.62,48.5 247,48.88 247,48.88 248.14,50.02 250.17,50.02
+3.3V_ALW on IN1 (solid shape): 248.53,47.47 247.89,46.82 246.72,46.82 246.59,46.95 246.59,48.58 247.2,49.19 248.53,49.19
+3.3V_ALW on IN1 (solid shape): 223.35,116.13 223.35,114.62 222.79,114.06 220.88,114.06 220.21,114.73 220.21,116.22 220.68,116.69 222.79,116.69
+3.3V_ALW on IN1 (solid shape): 111.69,33.91 111.84,33.66 112.12,33.6 112.12,30.85 110.24,28.97 103.69,28.97 103.39,29.27 103.39,30.94 106.36,33.91
+3.3V_ALW on IN1 (solid shape): 222.79,36.13 222.79,35.03 222.46,34.7 214.01,34.7 213.7,34.89 213.38,34.7 211.91,34.7 211.82,34.78 211.82,35.77 211.92,35.88 214.74,35.88 214.87,35.75 217.02,35.75 217.03,35.71 217.38,35.42 217.73,35.71 217.74,35.75 217.94,35.75 217.95,35.71 218.3,35.42 218.65,35.71 218.65,35.75 221.27,35.75 221.8,36.28 222.64,36.28
+3.3V_ALW on IN1 (solid shape): outline of 118 points within 84.01,26.63 91.8,31.48
+3.3V_ALW on IN1 (solid shape): outline of 304 points within 222.93,72.71 227.17,89.27
+3.3V_ALW on SVCC (solid shape): 241.72,44.73 241.77,44.29 242.21,44.24 242.71,43.74 242.71,38.07 241.63,36.99 234.76,36.99 234.56,36.96 234.4,36.85 231.6,34.05 231.23,34.38 230.89,34.02 210.23,34.02 209,35.25 208.84,35.36 208.64,35.39 193.07,35.39 192.85,35.48 192.62,35.39 191.35,35.39 189.92,36.82 189.92,39.6 191.18,40.85 195.89,40.85 196.09,40.89 196.25,41 198.52,43.27 235.49,43.27 235.68,43.31 235.85,43.42 237.53,45.1 241.35,45.1
+3.3V_ALW on IN2 (solid shape): 248.14,48.75 248.14,46.98 247.63,46.47 247,46.47 246.62,46.85 246.62,48.5 247,48.88 248.01,48.88
+3.3V_ALW on IN2 (solid shape): outline of 350 points within 221.6,31.86 233.54,36.89
+3.3V_ALW on IN2 (solid shape): outline of 1570 points within 108.54,29.12 192.08,41.13
+3.3V_AUDIO on TOP (solid shape): 269.53,39.76 269.53,38.77 269.71,38.59 270.8,38.59 271.06,38.33 271.06,38.25 271.59,37.73 271.59,37.2 271.51,37.12 269.88,37.12 269.2,36.44 268.92,36.44 268.84,36.51 268.84,37.02 269.32,37.5 269.32,38.8 269.34,38.8 269.34,39.75 269.38,39.79 269.5,39.79
+3.3V_AUDIO on BOTTOM (solid shape): 272.93,39.2 272.93,38.9 272.83,38.8 271.99,38.8 270.77,37.58 270.01,37.58 269.53,38.06 269.53,38.16 269.35,38.34 269.35,39.23 269.45,39.33 272.8,39.33
+3.3V_AUDIO on IN2 (solid shape): outline of 176 points within 257.21,38.01 271.13,45.35
+3.3V_AUX on TOP (solid shape): 71.81,27.82 71.94,27.82 72.37,27.39 72.37,25.51 72.25,25.39 69.63,25.39 65.13,29.88 65.13,31.36 65.26,31.48 68.16,31.48
+3.3V_AUX on TOP (solid shape): 82.26,34.42 82.26,33.91 83.45,32.73 83.45,30.03 82.96,29.55 81.42,29.55 80.53,30.44 80.53,34.46 80.74,34.67 82.01,34.67
+3.3V_AUX on BOTTOM (solid shape): 69.96,43.93 69.96,43.67 67.42,41.13 66.66,41.13 66.4,41.39 66.4,42.02 68.44,44.06 69.83,44.06
+3.3V_AUX on BOTTOM (solid shape): 82.14,34.42 82.14,33.91 82.52,33.53 83.15,33.53 83.53,33.15 83.53,31.75 83.41,31.62 81.5,31.62 80.49,32.64 80.49,34.29 80.74,34.54 82.01,34.54
+3.3V_AUX on BOTTOM (solid shape): 72.5,26.28 72.5,26.07 70.98,26.07 70.95,26.05 70.95,25.87 70.98,25.84 72.5,25.84 72.5,25.49 72.4,25.39 70.83,25.39 70.71,25.26 70.71,20.95 70.58,20.83 69.18,20.83 69.06,20.95 69.06,25.7 69.68,26.33 72.45,26.33
+3.3V_AUX on IN1 (solid shape): outline of 109 points within 65.74,30.54 82.1,37.07
+3.3V_EC on TOP (solid shape): 211.77,35.01 211.77,33.26 212.17,32.85 212.17,32.5 212.05,32.37 211.08,32.37 210.88,32.57 210.88,34.94 211.11,35.17 211.62,35.17
+3.3V_EC on TOP (solid shape): 233.08,36.54 233.08,36 232.82,35.75 232.82,32.47 231.54,31.19 230.32,31.19 229.97,31.55 229.97,32.71 230.82,33.56 231.5,33.56 231.78,33.84 231.78,35.01 231.66,35.14 231,35.14 230.92,35.22 230.92,35.75 231.05,35.88 231.28,35.88 231.43,36.03 231.43,36.66 231.58,36.82 232.8,36.82
+3.3V_EC on TOP (solid shape): 228.48,34.66 228.48,33.03 227.41,31.96 227.41,31.92 227.41,31.91 227.37,31.78 227.38,31.64 227.39,31.61 227.26,31.48 226.91,31.48 226.42,31.97 226.42,32.14 226.27,32.29 224.49,32.29 224.29,32.09 224.29,31.08 224.06,30.85 222.56,30.85 222.44,30.97 222.44,31.86 222.54,31.96 222.92,31.96 222.99,31.89 222.99,31.36 223.07,31.28 223.6,31.28 223.82,31.49 223.82,32.51 223.96,32.65 223.96,33.29 224.11,33.44 227.36,33.44 227.8,33.87 227.8,34.27 227.8,34.28 227.82,34.4 227.8,34.53 227.8,34.54 227.8,34.71 227.9,34.81 228.33,34.81
+3.3V_EC on BOTTOM (solid shape): 230.03,34.12 230.03,32.98 231.07,31.94 231.07,31.63 230.95,31.51 229.7,31.51 228.76,32.45 227.67,32.45 227.44,32.22 227.44,31.96 227.36,31.77 227.4,31.57 227.29,31.46 227.08,31.46 226.93,31.61 226.93,34.15 227.19,34.4 229.75,34.4
+3.3V_EC on BOTTOM (solid shape): 224.49,32.98 224.49,32.22 224.32,32.04 224.32,31.36 224.39,31.28 224.39,29.55 224.34,29.5 224.26,29.5 224.21,29.55 224.21,31.2 224.19,31.23 223.93,31.23 223.81,31.36 223.81,31.91 223.6,32.12 223.33,32.12 222.99,31.79 222.99,31.58 222.87,31.46 222.36,31.46 222.36,31.69 222.72,32.04 222.72,33.44 222.84,33.56 223.91,33.56
+3.3V_EC on IN1 (solid shape): outline of 327 points within 210.6,30.69 224.4,32.93
+3.3V_EC on IN2 (solid shape): outline of 848 points within 221.17,36.03 234.55,42.35
+3.3V_RTC_LDO on IN3 (solid shape): outline of 172 points within 25.69,8.16 30.67,11.21
+3.3V_RUN on TOP (solid shape): 65.43,28.65 65.43,27.46 65.18,27.21 63.33,27.21 63.15,27.39 63.15,28.79 63.43,29.07 65.01,29.07
+3.3V_RUN on TOP (solid shape): 313.83,80.83 313.83,80.35 313.72,80.25 312.38,80.25 312.17,80.45 312.17,80.89 312.25,80.96 313.7,80.96
+3.3V_RUN on TOP (solid shape): 22.21,94.68 22.21,93.13 21.98,92.9 19.95,92.9 19.79,93.05 19.79,94.07 19.97,94.25 19.97,95.62 20.15,95.79 21.09,95.79
+3.3V_RUN on TOP (solid shape): 89.34,34.12 89.34,33.18 89.14,32.98 89.14,32.12 88.76,31.74 87.49,31.74 86.22,30.47 85.07,30.47 84.83,30.71 84.83,34.03 85.28,34.48 88.98,34.48
+3.3V_RUN on TOP (solid shape): 238.57,30.34 238.57,27.72 238.46,27.62 236.63,27.62 236.43,27.82 236.43,28.89 236.48,28.94 237.68,28.94 237.75,29.02 237.75,29.45 237.77,29.46 237.77,30.33 237.96,30.52 238.39,30.52
+3.3V_RUN on TOP (solid shape): 275.65,47.03 275.65,46.52 276.21,45.96 276.21,45.58 277.1,44.69 277.1,43.5 276.72,43.12 275.01,43.12 274.53,43.6 274.53,46.14 274.58,46.19 274.58,47.13 274.81,47.36 275.32,47.36
+3.3V_RUN on TOP (solid shape): 193.05,34.58 193.17,34.52 193.3,34.5 193.64,34.5 193.76,34.38 193.76,30.64 194.7,29.7 195.34,29.7 195.66,29.38 195.66,28.99 195.56,28.89 194.24,28.89 192.98,30.15 191.33,30.15 191.09,29.91 190.25,29.91 189.85,29.5 189.09,29.5 188.78,29.81 188.78,30.76 189.9,31.88 191.99,31.88 192.46,32.35 192.46,33.21 192.31,33.36 191.35,33.36 191.24,33.46 191.24,34.5 191.32,34.58
+3.3V_RUN on TOP (solid shape): 175.4,109.97 175.4,109.43 175.83,109 176.31,109 176.61,108.7 176.61,99.17 176.79,99 177.68,99 177.86,98.82 177.86,96.86 177.99,96.73 178.77,96.73 178.93,96.58 178.93,94.75 178.7,94.52 177.76,94.52 177.25,95.03 177.25,95.57 177,95.82 176.69,95.82 175.5,97.01 174.16,97.01 174.05,97.17 173.87,97.26 173.87,98 174,98.13 174.53,98.13 174.63,98.23 174.63,98.79 174.46,98.97 173.74,98.97 173.67,99.05 173.03,99.05 172.98,99 172.98,97.78 172.86,97.65 172.5,97.65 172.42,97.73 172.42,99.38 172.58,99.53 174.46,99.53 174.66,99.73 174.66,101.61 174.63,101.64 173.41,101.64 173.24,101.46 173.24,100.7 172.98,100.44 172.6,100.44 172.47,100.57 172.47,103.08 172.58,103.19 173.36,103.19 173.57,102.98 173.57,102.58 173.74,102.4 174.71,102.4 174.89,102.58 174.89,104.48 174.58,104.79 173.57,104.79 173.46,104.89 173.46,106.06 173.57,106.16 175.45,106.16 175.55,106.26 175.55,107.73 175.42,107.86 173.67,107.86 173.57,107.96 173.57,109.92 173.74,110.1 175.27,110.1
+3.3V_RUN on BOTTOM (solid shape): 171.97,86.6 171.97,85.56 171.51,85.1 171.2,85.1 171,85.3 171,85.89 171.1,85.99 171.1,86.6 171.23,86.73 171.84,86.73
+3.3V_RUN on BOTTOM (solid shape): 165.51,92.09 166.05,92.09 166.2,91.93 166.2,91.58 166.05,91.43 165.59,91.43 165.34,91.68 165.01,91.68 164.75,91.43 164.42,91.43 164.32,91.53 164.32,91.98 164.4,92.06 164.91,92.06 165.08,92.24 165.36,92.24
+3.3V_RUN on BOTTOM (solid shape): outline of 86 points within 163.94,95.03 170.95,104.02
+3.3V_RUN on IN1 (solid shape): 176.59,108.93 176.59,108.16 176.36,107.94 174.23,107.94 173.49,108.67 173.49,108.98 173.59,109.08 176.44,109.08
+3.3V_RUN on IN1 (solid shape): 156.14,113.14 156.14,112.51 155.89,112.25 151.72,112.25 151.54,112.43 151.54,112.86 152.08,113.4 155.89,113.4
+3.3V_RUN on SVCC (solid shape): outline of 1101 points within 45.96,25.01 290.05,54.6
+3.3V_RUN on IN2 (solid shape): 50.35,44.61 50.35,41.44 50.12,41.21 48.6,41.21 48.45,41.36 48.45,44.61 48.8,44.97 50,44.97
+3.3V_RUN on IN2 (solid shape): 22.44,94.48 22.44,93.64 22.29,93.48 21.66,93.48 21.61,93.43 20.77,93.43 20.75,93.46 20.75,94.5 21.26,95.01 21.9,95.01
+3.3V_RUN on IN2 (solid shape): outline of 907 points within 166.58,45.13 193.56,98.16
+3.3V_RUN on IN2 (solid shape): outline of 1334 points within 145.12,91.5 155.96,113.3
+3.3V_RUN on IN2 (solid shape): outline of 1443 points within 275.69,48.45 313.7,88.02
+3.3V_RUN on IN3 (solid shape): 152.99,113.35 152.99,112.56 152.78,112.34 151.07,112.34 150.71,112.71 150.71,113.4 150.88,113.57 152.76,113.57
+3.3V_RUN on IN3 (solid shape): outline of 170 points within 247.12,27.98 262.01,33.34
+3.3V_RUN_F on TOP (solid shape): 23.96,97.45 23.96,96.79 23.83,96.66 22.69,96.66 22.64,96.71 21.9,96.71 21.57,96.38 20.13,96.38 19.87,96.63 19.87,97.45 20,97.57 21.08,97.57 21.17,97.66 23.75,97.66
+3.3V_RUN_F on BOTTOM (solid shape): 23.99,97.6 24.92,97.6 24.92,97.32 23.96,97.32 23.88,97.24 23.88,97.14 23.96,97.06 24.92,97.06 24.92,96.86 23.71,96.86 23.39,96.54 22.78,96.54 22.4,96.92 22.4,97.46 22.65,97.71 23.88,97.71
+3.3V_SUS on TOP (solid shape): 176.78,83.21 176.78,80.44 174.76,78.42 173.49,78.42 173.36,78.55 173.36,79.01 173.77,79.41 174.38,79.41 174.89,79.92 174.89,80.81 174.58,81.11 173.54,81.11 173.46,81.19 173.46,83.6 173.52,83.65 176.34,83.65
+3.3V_SUS on TOP (solid shape): 174.96,90.28 176.28,90.28 176.64,89.93 176.64,87.9 176.61,87.9 176.41,87.69 175.5,87.69 175.27,87.46 175.27,87.03 175.14,86.9 174.13,86.9 173.97,86.75 173.97,86.27 173.92,86.22 173.59,86.22 173.49,86.32 173.49,87.72 173.55,87.78 173.78,87.78 174.23,88.23 174.23,89.04 174.46,89.42 174.23,89.8 174.23,89.83 174,90.05 174,90.46 174.18,90.64 174.61,90.64
+3.3V_SUS on BOTTOM (solid shape): 171.31,75.7 171.31,72.45 171.23,72.38 170.98,72.38 170.9,72.45 170.9,75.68 170.95,75.73 171.28,75.73
+3.3V_SUS on BOTTOM (solid shape): 195.69,43.19 195.69,42.63 195.61,42.56 193.91,42.56 193.81,42.45 192.72,42.45 192.64,42.53 190.49,42.53 190.35,42.67 190.35,43.41 190.47,43.53 193.51,43.53 193.52,43.55 195.33,43.55
+3.3V_SUS on BOTTOM (solid shape): 174.68,90.41 174.68,89.27 174.58,89.17 173.59,89.17 173.49,89.27 173.49,89.55 173.39,89.65 172.75,89.65 172.6,89.5 172.6,88.48 172.12,88 171.13,88 171.05,88.07 171.05,88.45 171.13,88.53 171.71,88.53 172.09,88.91 172.09,89.78 172.3,89.98 173.13,89.98 173.44,90.28 173.44,90.38 173.62,90.56 174.53,90.56
+3.3V_SUS on BOTTOM (solid shape): 168.51,89.67 168.51,88.76 168.23,88.48 166.48,88.48 166.23,88.23 166.23,86.72 166.02,86.4 166.23,86.07 166.23,85.75 166.21,85.74 165.13,85.74 164.85,85.46 164.35,85.46 164.35,89.52 164.45,89.62 164.68,89.62 165.34,88.96 167.34,88.96 167.55,89.17 167.55,89.57 167.72,89.75 168.44,89.75
+3.3V_SUS on BOTTOM (solid shape): 173.95,83.25 173.95,82.18 174.66,81.47 174.66,80.68 174.63,80.66 174.58,80.66 174,80.38 174.57,80.1 174.63,80.1 174.66,80.07 174.66,78.42 173.44,77.2 170.8,77.2 170.67,77.33 170.67,78.4 170.87,78.6 172.12,78.6 172.55,79.03 172.55,80.05 172.35,80.25 170.62,80.25 170.21,80.66 170.21,82.71 170.52,83.02 170.92,83.02 171.43,82.51 173.34,82.51 173.49,82.66 173.49,83.25 173.54,83.3 173.9,83.3
+3.3V_SUS on IN2 (solid shape): 172.3,78.27 172.3,75.5 170.9,74.1 170.9,72.33 170.54,71.97 168.28,71.97 168.03,72.22 168.03,76.47 170.24,78.68 171.89,78.68
+3.3V_SUS on IN2 (solid shape): outline of 81 points within 167.22,88.81 174.56,94.88
+3.3V_SUS on IN2 (solid shape): outline of 320 points within 176.59,38.34 207.25,51.79
+3.3V_SUS on IN2 (solid shape): outline of 311 points within 148.93,85.33 154.8,91.32
+3.3V_SUS on IN3 (solid shape): outline of 995 points within 153.22,88.01 169.4,95.5
+3.3V_TP_PWR on BOTTOM (solid shape): 192.49,29.3 192.49,27.52 192.31,27.34 192.06,27.34 191.93,27.21 191.93,26.1 191.55,25.72 190.79,25.72 190.66,25.84 190.66,27.06 190.81,27.21 190.81,28.03 190.41,28.43 188.39,28.43 188.3,28.52 188.2,28.61 188.07,28.66 187.92,28.81 187.92,29.27 187.97,29.32 191.55,29.32 191.8,29.58 192.21,29.58
+3V_GFX on TOP (solid shape): 220.84,117.08 220.84,115.48 220.68,115.33 217.86,115.33 217.28,115.91 217.28,117.03 217.43,117.18 220.73,117.18
+3V_GFX on TOP (solid shape): outline of 902 points within 177.35,67.5 191.68,100.39
+3V_GFX on BOTTOM (solid shape): 183.47,79.92 183.47,79.46 183.7,79.23 187.98,79.23 188.05,79.17 188.05,78.82 187.95,78.72 185.67,78.72 185.43,78.47 185.43,78.32 185.17,78.07 184.16,78.07 183.9,78.32 183.9,78.52 183.64,78.79 183.08,78.79 182.79,79.08 182.79,79.89 182.89,80 183.4,80
+3V_GFX on BOTTOM (solid shape): 190.02,89.2 190.1,89.16 190.12,89.07 190.36,88.62 190.81,88.89 190.81,88.9 191.11,89.2 191.71,89.2 191.93,88.99 191.93,88.96 191.94,88.85 191.98,88.75 191.98,87.97 191.85,87.84 190.03,87.84 189.85,88.02 189.49,88.02 189.26,87.79 188.5,87.79 187.61,88.68 187.61,89.14 187.68,89.2
+3V_GFX on BOTTOM (solid shape): 188.65,100.63 188.68,100.55 188.63,100.47 188.59,99.93 189.13,99.98 189.21,100.02 189.29,99.99 189.47,99.81 189.47,99.3 188.98,98.82 187.61,98.82 187.43,99 187.43,99.31 187.47,99.39 187.55,99.41 187.87,99.58 187.78,99.93 187.78,100.23 187.85,100.31 187.85,100.41 187.88,100.47 187.89,100.52 188.01,100.64 188.03,100.64 188.11,100.66 188.19,100.7 188.58,100.7
+3V_GFX on IN1 (solid shape): 218.7,116.29 218.7,115.84 218.52,115.66 216.47,115.66 215.48,116.65 215.48,117.03 215.88,117.44 217.56,117.44
+3V_GFX on IN1 (solid shape): 187.79,100.6 188.35,100.6 188.45,100.49 188.45,98.97 188.32,98.84 187.28,98.84 186.44,99.68 186.44,100.7 186.67,100.93 187.46,100.93
+3VLANVCC on TOP (solid shape): 286.7,46.7 286.7,46.49 286.32,46.11 286.32,43.27 285.61,42.56 285.61,41.52 285.22,41.13 284.34,41.13 284.08,41.39 284.08,43.34 283.9,43.52 283.9,43.95 284.08,44.13 284.08,44.44 284.34,44.69 284.36,44.69 285.76,46.09 285.78,46.09 285.83,46.14 285.83,46.62 285.89,46.67 286.27,46.67 286.42,46.82 286.57,46.82
+3VLANVCC on BOTTOM (solid shape): 286.39,43.8 286.39,43.47 285.76,42.84 285.76,41.67 285.61,41.52 284.79,41.52 284.69,41.62 284.69,42.05 283.98,42.76 283.98,43.85 284.01,43.88 286.32,43.88
+3VLANVCC on IN2 (solid shape): 286.38,44 286.46,43.97 286.48,43.89 286.5,43.74 286.57,43.62 286.57,42.53 286.32,42.28 286.32,40.73 285.81,40.22 285.81,39.69 286.16,39.33 291.09,39.33 292.08,40.32 292.08,42.38 292.29,42.58 292.95,42.58 293.18,42.35 293.18,39.94 291.66,38.43 289.58,38.43 289.39,38.62 288.7,38.62 288.2,38.11 288.2,37.02 288.02,36.84 287.98,36.84 287.82,36.88 287.65,36.84 286.44,36.84 286.34,36.85 286.24,36.84 285.48,36.84 284.16,38.16 284.16,43.17 283.98,43.35 283.98,43.9 284.08,44
+5V_ALW on TOP (solid shape): 235.35,23.65 235.59,23.65 235.59,24.6 236.08,24.6 236.18,24.5 236.18,21.17 236.05,21.04 235.59,21.04 235.59,22.04 235.35,22.04 235.35,21.04 232.14,21.04 231.83,21.35 231.83,22.97 232.06,23.2 233.49,23.2 234.3,24.01 234.3,24.37 234.53,24.6 235.35,24.6
+5V_ALW on TOP (solid shape): 146.9,26.55 150.63,26.55 151.86,25.32 151.86,24.41 152.33,23.94 152.33,21.22 151.9,20.79 147.35,20.79 146.97,21.17 146.97,21.75 145.91,22.82 145.19,22.82 145.18,22.83 144.45,22.83 144.2,23.07 144.2,24.85 145.73,26.38 145.73,27.01 145.86,27.14 146.31,27.14
+5V_ALW on BOTTOM (solid shape): 173.11,122.62 173.11,119.39 172.35,118.63 167.87,118.63 167.67,118.83 167.67,122.41 168.95,122.41 169,122.46 169.76,122.46 169.91,122.31 169.91,121.88 170.19,121.6 170.87,121.6 171.2,121.93 171.2,122.67 171.46,122.92 172.8,122.92
+5V_ALW on BOTTOM (solid shape): 304.27,66.41 306.18,66.41 306.43,66.15 306.43,65.65 306.18,65.39 304.4,65.39 304.27,65.26 304.27,63.99 303.77,63.49 302.32,63.49 302.04,63.77 302.04,65.24 302.58,65.78 305.99,65.78 305.99,66.02 304.54,66.02 304.54,65.78 302.58,65.78 302.62,65.82 302.62,66.41 302.85,66.64 304.05,66.64
+5V_ALW on BOTTOM (solid shape): 29.12,58.71 29.12,58.05 28.79,57.73 28.43,57.73 27.95,57.24 27.95,56.89 27.89,56.83 26.81,56.83 26.75,56.88 26.75,57.9 26.77,57.91 26.77,58.49 26.09,59.17 26.09,60.11 26.17,60.18 27.64,60.18
+5V_ALW on BOTTOM (solid shape): 151.9,24.95 151.9,24.19 152.23,23.86 152.23,22.57 151.95,22.29 151.27,22.29 151.06,22.08 151.06,21.68 150.91,21.53 150.68,21.53 150.17,21.02 150.17,19.93 148.85,18.6 148.85,17.88 148.52,17.55 144.88,17.55 144.31,18.12 144.31,24.45 144.98,25.12 144.98,25.73 145.68,26.43 145.68,27.33 145.82,27.47 149.39,27.47
+5V_ALW on BOTTOM (solid shape): 23.89,62.91 23.89,61.39 23.41,60.91 23.41,60.58 23.02,60.18 22.33,60.18 21.95,59.8 20.73,59.8 20.58,59.65 20.58,59.61 20.58,59.61 20.58,58.17 20.56,58.15 20.23,58.15 20.18,58.2 20.18,59.7 20.09,59.79 19.99,59.79 19.92,59.73 19.92,58.23 19.85,58.15 19.57,58.15 19.52,58.2 19.52,59.61 19.52,59.61 19.48,60.71 20.2,61.43 20.79,61.43 21.55,62.19 21.55,64.14 21.67,64.27 22.54,64.27
+5V_ALW on IN1 (solid shape): 105.72,78.8 105.39,78.47 103.74,78.47 103.34,78.88 103.34,83.17 103.74,83.58 105.72,83.58
+5V_ALW on IN1 (solid shape): outline of 965 points within 126.68,105.85 173.08,123.07
+5V_ALW on IN1 (solid shape): outline of 1374 points within 147.15,17.51 181.72,31.61
+5V_ALW on SVCC (solid shape): outline of 2765 points within 2.03,2.03 326.79,109.37
+5V_ALW on IN2 (solid shape): 106.6,80.5 106.6,76.26 106.07,75.73 104.3,75.73 103.95,76.08 103.95,80.87 104.5,81.43 105.67,81.43
+5V_ALW on IN2 (solid shape): 107.51,26.11 107.72,26.11 108.64,25.18 109.33,25.18 109.43,25.08 109.43,22.85 109,22.41 107.5,22.41 104.88,25.03 104.88,26.35 105.67,27.14 106.49,27.14
+5V_ALW on IN2 (solid shape): outline of 180 points within 103.08,40.85 107.27,56.22
+5V_AUDIO on TOP (solid shape): 300.97,43.65 303.54,43.65 303.89,43.29 303.89,42.4 303.77,42.28 302.62,42.28 302.5,42.15 300.72,42.15 300.59,42.02 300.59,41.26 300.34,41.01 297.92,41.01 297.16,41.77 297.16,43.42 297.54,43.8 300.82,43.8
+5V_AUDIO on BOTTOM (solid shape): 308.99,41.22 308.99,40.46 308.89,40.36 307.84,40.36 307.36,40.84 307.36,41.43 307.49,41.55 308.66,41.55
+5V_AUDIO on BOTTOM (solid shape): 301.3,43.65 301.3,41.77 301.23,41.69 299.47,41.69 299.46,41.71 298.88,41.71 298.76,41.82 298.76,43.83 298.84,43.91 301.05,43.91
+5V_FAN on BOTTOM (solid shape): 106.28,53.58 106.28,52.61 105.88,52.21 105.16,52.21 104.99,52.39 102.01,52.39 101.91,52.28 99.98,52.28 99.8,52.46 99.8,53.14 99.87,53.21 101.84,53.21 102.34,53.71 106.15,53.71
+5V_FAN2 on TOP (solid shape): 246.67,54.17 246.67,54.16 247.46,53.38 247.46,53.07 247.25,52.87 246.57,52.87 246.34,53.1 245.6,53.1 245.37,52.87 244.81,52.87 244.61,53.07 244.61,54.42 244.71,54.52 246.09,54.52
+5V_FAN2 on BOTTOM (solid shape): 237.17,59.12 240.8,59.12 241.71,58.2 241.79,58.2 242.62,57.43 244.15,56.17 245.83,54.98 245.98,54.89 245.98,53.83 245.47,53.33 245.14,53.33 245.02,53.45 245.02,55.05 244.92,55.15 242.58,55.15 242.45,55.28 240.93,55.28 240.85,55.36 240.85,57.11 239.88,58.08 237.04,58.08 235.85,59.27 235.24,59.27 235.06,59.45 235.06,59.8 235.11,59.85 236.43,59.85
+5V_HDMIF1 on BOTTOM (solid shape): 317.36,87.49 317.36,86.85 317.99,86.22 318.52,86.22 318.69,86.19 318.85,86.22 318.88,86.22 319.01,86.09 319.01,85.33 318.79,85.11 317.57,85.11 315.45,87.24 313.67,87.24 313.42,87.49 313.42,88.63 313.67,88.89 315.96,88.89
+5V_RUN on TOP (solid shape): 247.12,52.36 247.12,51.37 246.87,51.12 245.19,51.12 244.97,51.34 244.97,52.46 245.07,52.56 246.92,52.56
+5V_RUN on TOP (solid shape): 193.12,54.7 193.12,54.32 192.57,53.76 190.13,53.76 190.05,53.83 190.05,55.1 190.46,55.51 192.31,55.51
+5V_RUN on TOP (solid shape): 21.12,98.89 21.12,98 20.91,97.8 19.85,97.8 19.49,98.16 17.82,98.16 17.75,98.23 17.75,98.73 17.86,98.84 19.52,98.84 19.69,99.02 20.99,99.02
+5V_RUN on TOP (solid shape): 238.57,25.87 238.57,24.27 237.8,23.51 236.91,23.51 236.74,23.68 236.74,24.85 236.28,25.31 236.28,25.77 236.51,26 237.4,26 237.55,26.15 238.29,26.15
+5V_RUN on TOP (solid shape): 117.94,36.08 117.94,34.58 117.69,34.33 107.55,34.33 107.22,34.66 107.22,35.22 107.55,35.55 114.49,35.55 115.02,36.08 117.1,36.08 117.35,36.33 117.69,36.33
+5V_RUN on BOTTOM (solid shape): 312.02,89.06 312.02,87.49 311.51,86.98 310.12,86.98 309.61,87.49 309.61,89.14 309.99,89.52 311.56,89.52
+5V_RUN on BOTTOM (solid shape): 297.85,44.03 298.31,44.03 298.33,44 298.33,41.87 298.12,41.65 297.07,41.65 296.35,42.38 296.35,44.31 296.5,44.46 297.42,44.46
+5V_RUN on BOTTOM (solid shape): 290.38,31.43 290.38,31.42 290.86,30.95 290.86,26.42 291.32,25.96 291.32,22.74 290.76,22.19 288.55,22.19 288.04,22.69 288.04,25.49 288.91,26.35 288.91,28.18 288.73,28.36 288.73,31.41 288.93,31.61 290.2,31.61
+5V_RUN on SVCC (solid shape): 193.37,55.74 193.71,55.48 194.05,55.74 194.84,55.74 196.09,54.49 196.26,54.38 196.46,54.34 246.38,54.34 247.48,53.67 247.54,53.63 247.61,53.6 249.46,52.63 249.52,52.6 249.59,52.57 251.56,51.7 251.63,51.67 251.7,51.64 253.82,50.87 253.9,50.84 253.97,50.82 256.16,50.18 256.23,50.16 256.3,50.14 258.63,49.62 258.69,49.6 258.68,49.56 258.68,49.52 258.68,45.03 258.09,44.44 249.27,44.44 246.36,47.34 246.26,47.61 245.99,47.71 243.7,50 243.53,50.11 243.34,50.15 229.18,50.15 228.85,50.39 228.51,50.15 201.52,50.15 201.3,50.23 201.08,50.15 190.61,50.15 190.25,50.48 189.9,50.15 187.92,50.15 187.77,50.18 187.61,50.15 185.47,50.15 185.44,50.19 185.41,50.23 184.82,50.82 184.82,53.73 186.83,55.74
+5V_RUN on IN2 (solid shape): 311.77,89.14 311.77,87.36 311.13,86.73 309.86,86.73 309.23,87.36 309.23,88.76 309.99,89.52 311.39,89.52
+5V_RUN on IN2 (solid shape): 297.52,44.99 297.52,42.89 297.01,42.38 296.27,42.38 296.02,42.63 296.02,45.12 296.22,45.33 297.19,45.33
+5V_RUN on IN2 (solid shape): outline of 4856 points within 230.95,23.66 290.94,45.63
+5V_RUN_F on BOTTOM (solid shape): 23.97,98.58 24.83,98.58 24.83,98.32 23.98,98.32 23.8,98.14 23.26,98.14 23.14,98.27 23.14,98.73 23.2,98.79 23.75,98.79
+V1.05A_AOSCSUS on IN2 (solid shape): 160.43,89.8 160.43,89.17 160.18,88.91 159.34,88.91 159.16,89.09 159.16,89.88 159.29,90 160.23,90
+V1.05DX_MODPHY on TOP (solid shape): outline of 109 points within 163.2,116.57 170.11,122.92
+V1.05DX_MODPHY on TOP (solid shape): outline of 385 points within 153.17,93.2 157.29,109.76
+V1.05DX_MODPHY on BOTTOM (solid shape): 161.81,119.49 165.32,119.49 165.52,119.3 165.52,118.7 164.68,117.87 164.68,117.42 163.66,116.39 160.18,116.39 160.05,116.52 159.39,116.52 159.24,116.67 159.24,119.37 159.57,119.7 161.6,119.7
+V1.05DX_MODPHY on BOTTOM (solid shape): 156.37,109.08 156.37,106.77 156.07,106.46 153.93,106.46 153.78,106.62 153.78,107.28 153.98,107.48 154.14,107.48 154.39,107.73 154.39,108.16 154.24,108.32 154.24,109.31 154.29,109.36 156.09,109.36
+V1.05DX_MODPHY on BOTTOM (solid shape): 155.46,96.15 155.46,96.1 155.38,95.92 155.41,95.73 155.42,95.72 155.42,95.61 155.3,95.4 155.42,95.19 155.44,95.15 155.43,95.12 155.41,95.06 155.39,95.01 155.38,94.96 155.38,94.9 155.38,94.88 155.34,94.84 155.34,94.58 155.31,94.51 155.06,94.26 154.99,94.24 154.93,94.25 154.92,94.31 154.86,94.67 154.5,94.69 154.47,94.69 154.41,94.64 154.41,94.6 154.37,94.45 154.41,94.3 154.41,94.09 154.29,93.97 153.91,93.97 153.4,94.47 153.4,94.89 153.47,94.92 153.5,94.94 153.6,95.06 153.64,95.21 153.67,95.27 153.74,95.3 153.94,95.38 154.02,95.58 154.02,95.64 154.05,95.73 154.14,95.75 154.4,95.82 154.5,96.06 154.5,96.18 154.57,96.25 155.35,96.25
+V1.05DX_MODPHY on IN2 (solid shape): outline of 1720 points within 153.35,93.84 165.82,119.51
+V1.05S_APLLOPI on TOP (solid shape): 148.32,90.84 148.32,89.78 147.51,88.96 145.73,88.96 145.4,88.63 145.4,87.31 145.22,87.13 144.05,87.13 143.92,87.26 143.92,88.71 144.43,89.22 144.43,89.9 144.59,90.05 145.55,90.05 145.7,89.9 147.73,89.9 147.86,90.03 147.86,90.56 147.84,90.59 147.84,90.79 147.94,90.89 148.27,90.89
+V1.05S_ASATA3PLL on BOTTOM (solid shape): 159.69,108.84 159.69,106.35 159.75,106.29 159.75,104.79 159.7,104.74 159.06,104.74 159.06,104.74 158.23,104.74 158.07,104.58 157.92,104.58 157.82,104.68 157.82,105.65 157.89,105.73 157.89,106.34 157.82,106.41 157.82,108.49 156.78,109.54 154.29,109.54 153.98,109.84 153.98,110.02 155.81,110.02 155.81,109.99 155.82,109.94 155.84,109.89 155.86,109.84 155.89,109.8 155.92,109.76 155.97,109.72 156.01,109.7 156.06,109.68 156.11,109.67 156.17,109.66 156.22,109.67 156.27,109.68 156.32,109.7 156.37,109.72 156.41,109.76 156.45,109.8 156.48,109.84 156.5,109.89 156.52,109.94 156.52,109.99 156.52,110.05 156.52,110.1 156.5,110.15 156.48,110.2 156.45,110.24 156.41,110.28 156.37,110.31 156.32,110.34 156.27,110.36 156.22,110.37 156.17,110.38 156.11,110.37 156.06,110.36 156.01,110.34 155.97,110.31 155.92,110.28 155.89,110.24 155.86,110.2 155.84,110.15 155.82,110.1 155.81,110.05 155.81,110.02 153.98,110.02 153.98,111.09 154.01,111.11 157.41,111.11
+V1.05S_AUSB3PLL on BOTTOM (solid shape): 152.15,107.02 152.15,106.01 152.26,105.9 152.26,105.76 153.68,105.76 153.68,105.77 153.71,105.8 155.23,105.8 155.33,105.7 155.33,105.18 155.19,105.04 153.61,105.04 153.43,104.86 152.62,104.86 152.47,104.71 152.45,104.7 152.44,104.71 152.27,104.7 152.11,104.66 152.1,104.66 151.7,104.66 151.54,104.82 151.53,104.83 151.52,104.86 151.52,105.17 151.51,105.28 151.47,105.39 151.47,105.67 151.51,105.77 151.52,105.88 151.52,106.19 151.51,106.29 151.47,106.39 151.47,106.4 151.47,106.54 151.47,106.55 151.49,106.72 151.47,106.89 151.47,106.89 151.47,107.05 151.6,107.17 152,107.17
+V1.05S_AXCK_DCB on TOP (solid shape): 150.82,100.53 150.82,99.82 150.81,99.81 150.81,99.5 150.63,99.33 150.05,99.33 149.8,99.57 149.8,100.4 150,100.6 150.76,100.6
+V1.05S_AXCK_LCPLL on BOTTOM (solid shape): 151.44,108.85 151.44,107.56 151.37,107.48 149.46,107.48 149.13,107.15 149.13,104.76 149.03,104.66 148.47,104.66 148.41,104.72 148.41,106.59 148.4,106.6 148.4,107.3 147.91,107.78 147.91,108.44 148.04,108.57 149.59,108.57 149.92,108.9 151.39,108.9
+V1.05S_VCCST on TOP (solid shape): 145.86,94.35 145.86,93.25 146.19,92.92 147.4,92.92 147.46,92.87 147.46,92.16 146.95,91.65 145.5,91.65 145.35,91.81 145.35,93.94 145.19,94.09 145.19,94.3 145.32,94.42 145.78,94.42
+V3.3_THERMAL2 on TOP (solid shape): 184.64,63.36 184.64,63.03 184.56,62.95 182.46,62.95 182.43,62.98 182.43,63.31 182.46,63.33 184.08,63.33 184.21,63.46 184.54,63.46
+V3.3_THERMAL2 on TOP (solid shape): 184.29,66.92 185.53,66.92 185.68,66.76 185.68,65.95 185.53,65.8 182.99,65.8 182.81,65.98 182.81,66.84 183.12,67.14 184.06,67.14
+V3.3_THERMAL2 on TOP (solid shape): 177.3,68.08 177.3,66.99 177.27,66.97 175.07,66.97 174.94,67.09 174.94,67.91 175.14,68.11 176.06,68.11 176.23,68.29 177.1,68.29
+V3.3_THERMAL2 on TOP (solid shape): 173.62,64.76 173.62,63.64 173.63,63.63 173.63,62.74 173.82,62.55 174.68,62.55 174.81,62.42 174.81,62.32 174.89,62.24 175.75,62.24 175.88,62.37 175.88,63.66 175.9,63.69 176.08,63.69 176.13,63.64 176.13,62.5 176.31,62.32 176.31,61.76 176,61.45 173.41,61.45 172.5,62.37 172.5,64.68 172.73,64.91 173.46,64.91
+V3.3_THERMAL2 on IN2 (solid shape): 176.54,67.14 176.54,66.2 176.53,66.08 176.54,65.95 176.54,65.67 176.89,65.31 176.89,63.46 176.4,62.96 174.26,62.96 172.91,64.32 172.91,66.84 173.54,67.47 176.21,67.47
+V3.3DX_CR on TOP (solid shape): 62.19,28.38 62.19,27.57 61.95,27.33 59.05,27.33 58.83,27.55 57.77,27.55 57.56,27.75 57.56,28.79 57.72,28.94 61.63,28.94
+V3.3DX_CR on TOP (solid shape): 62.7,39.41 62.7,38.16 62.37,37.83 62.37,37.32 62.24,37.2 60.79,37.2 60.59,37.4 59.44,37.4 59.39,37.45 59.39,37.53 59.44,37.58 61.37,37.58 61.58,37.78 61.58,39.08 61.48,39.18 61.48,39.43 61.65,39.61 62.49,39.61
+V3.3DX_CR on IN2 (solid shape): outline of 1174 points within 52.43,27.9 62.67,42.12
+V3.3S_1.8S_LPSS_SDIO on IN2 (solid shape): 160.61,93.66 160.61,92.98 160.41,92.77 159.65,92.77 159.44,92.98 159.44,93.66 159.57,93.79 160.49,93.79
+VCCIN on TOP (solid shape): outline of 2597 points within 124.6,86.5 146.82,119.24
+VCCIN on BOTTOM (solid shape): 138.96,121.74 138.96,121.17 138.88,121.09 136.24,121.09 136.24,120.59 139.3,120.59 139.45,120.44 139.45,115.81 139.78,115.48 143.06,115.48 143.21,115.33 143.21,113.52 142.91,113.22 127.36,113.22 127.23,113.36 127.23,113.52 127.26,113.93 126.88,114.1 126.86,114.1 126.73,114.24 126.73,115.33 126.86,115.45 129.98,115.45 130.23,115.71 130.23,120.53 130.29,120.59 133.09,120.59 133.09,121.09 130.85,121.09 130.72,121.23 130.72,122.82 131.1,123.2 137.5,123.2
+VCCIN on BOTTOM (solid shape): outline of 515 points within 123.84,86.89 147.73,99.86
+VCCIN on SVCC (solid shape): outline of 320 points within 125.08,86.6 147.43,119.37
+VCCIN on IN2 (solid shape): outline of 2572 points within 124.6,86.5 145.14,119.24
+VIN on TOP (solid shape): 217.74,51.29 217.74,49.95 217.41,49.62 217.41,47.81 217.71,47.51 219.01,47.51 219.18,47.33 219.18,46.57 218.91,46.29 218.45,46.29 218.25,46.49 213.75,46.49 213.11,47.13 213.11,49.44 212.83,49.72 212.83,51.17 213.24,51.57 217.46,51.57
+VIN on TOP (solid shape): 206.59,126.22 206.59,125.67 205.34,124.42 205.34,123.24 205.2,123.09 201.23,123.09 200.77,123.56 200.77,124.65 200.64,124.78 199.86,124.78 199.7,124.93 199.7,125.41 199.75,125.46 200.59,125.46 200.77,125.64 200.77,126.35 200.9,126.48 206.33,126.48
+VIN on TOP (solid shape): 40.03,28.55 40.03,27.7 40.26,27.47 40.26,26.66 40.28,26.63 42.17,26.63 42.3,26.5 42.3,22.47 41.49,21.65 38.08,21.65 38.06,21.68 38.06,23.74 37.68,24.12 37.1,24.12 36.86,24.36 36.86,25.29 36.23,25.92 36.23,26.73 36.25,26.76 37.04,26.76 38.96,28.68 39.91,28.68
+VIN on TOP (solid shape): 153.87,124.05 153.87,121.99 151.87,120 151.87,118.58 151.47,118.17 149.51,118.17 149.08,118.6 148.45,118.6 148.32,118.73 148.32,120.13 148.06,120.38 145.78,120.38 145.32,119.92 125.38,119.92 124.09,121.22 121.95,121.22 121.65,120.92 121.65,119.29 121.17,118.81 119.19,118.81 119.01,118.99 119.01,123.05 119.26,123.3 126.2,123.3 126.55,122.95 138.45,122.95 139.32,123.81 145.55,123.81 145.55,121.27 146.05,120.76 148.81,120.76 149.31,121.27 149.33,121.27 149.46,121.4 149.46,121.42 149.59,121.55 149.59,123.66 149.46,123.79 149.46,123.81 149.21,124.07 149.19,124.07 149.14,124.12 145.85,124.12 145.55,123.81 139.32,123.81 139.42,123.91 139.42,126.47 139.56,126.61 151.32,126.61
+VIN on TOP (solid shape): outline of 932 points within 62.16,41.5 111.36,104.08
+VIN on BOTTOM (solid shape): 103.49,77.18 103.49,74.1 103.28,73.9 99.09,73.9 98.84,74.15 98.84,75.86 99.5,76.52 99.5,77.48 99.7,77.68 102.98,77.68
