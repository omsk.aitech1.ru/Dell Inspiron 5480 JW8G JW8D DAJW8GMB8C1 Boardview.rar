# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Nets (continued)
M_B_DQ46: JDIM1.158 U14.AV17
M_B_DQ47: JDIM1.160 U14.AU17
M_B_DQ48: JDIM1.165 U14.AR21
M_B_DQ49: JDIM1.163 U14.AR22
M_B_DQ50: JDIM1.174 U14.AL21
M_B_DQ51: JDIM1.176 U14.AM22
M_B_DQ52: JDIM1.164 U14.AN22
M_B_DQ53: JDIM1.166 U14.AP21
M_B_DQ54: JDIM1.175 U14.AK21
M_B_DQ55: JDIM1.177 U14.AK22
M_B_DQ56: JDIM1.183 U14.AN20
M_B_DQ57: JDIM1.180 U14.AR20
M_B_DQ58: JDIM1.192 U14.AK18
M_B_DQ59: JDIM1.194 U14.AL18
M_B_DQ60: JDIM1.182 U14.AK20
M_B_DQ61: JDIM1.181 U14.AM20
M_B_DQ62: JDIM1.193 U14.AR18
M_B_DQ63: JDIM1.191 U14.AP18
M_B_DQSN0: JDIM1.10 U14.AW30
M_B_DQSN1: JDIM1.27 U14.AV26
M_B_DQSN2: JDIM1.45 U14.AN28
M_B_DQSN3: JDIM1.62 U14.AN25
M_B_DQSN4: JDIM1.135 U14.AW22
M_B_DQSN5: JDIM1.152 U14.AV18
M_B_DQSN6: JDIM1.169 U14.AN21
M_B_DQSN7: JDIM1.186 U14.AN18
M_B_DQSP0: JDIM1.12 U14.AV30
M_B_DQSP1: JDIM1.29 U14.AW26
M_B_DQSP2: JDIM1.47 U14.AM28
M_B_DQSP3: JDIM1.64 U14.AM25
M_B_DQSP4: JDIM1.137 U14.AV22
M_B_DQSP5: JDIM1.154 U14.AW18
M_B_DQSP6: JDIM1.171 U14.AM21
M_B_DQSP7: JDIM1.188 U14.AM18
M_B_ODT: Q18.1 R167.2 R168.2
M_B_ODT0: JDIM1.116 R168.1
M_B_ODT1: JDIM1.120 R167.1
M_B_RAS#: JDIM1.110 U14.AM35
M_B_WE#: JDIM1.113 U14.AK35
MCP_RSVD_19: TP35.1 U14.AV63
MCP_RSVD_20: TP29.1 U14.AU63
MCP_RSVD_21: TP1.1 U14.C63
MCP_RSVD_22: TP2.1 U14.C62
MCP_RSVD_24: TP17.1 U14.A51
MCP_RSVD_25: TP3.1 U14.B51
MCP_RSVD_26: TP4.1 U14.L60
MCP_RSVD_69: TP45.1 U14.P60
MCP_RSVD_70: TP47.1 U14.P61
MCP_RSVD_71: TP40.1 U14.N59
MCP_RSVD_72: TP43.1 U14.N61
MDI0+: EC22.2 ESD5.6 U6.1 U19.1
MDI0-: EC21.2 ESD5.4 U6.2 U19.2
MDI1+: EC20.2 ESD5.1 U6.4 U19.5
MDI1-: EC19.2 ESD5.3 U6.5 U19.6
MDI2+: EC18.2 ESD4.6 U6.6 U19.7
MDI2-: EC17.2 ESD4.4 U6.7 U19.8
MDI3+: EC16.2 ESD4.1 U6.9 U19.11
MDI3-: EC15.2 ESD4.3 U6.10 U19.12
ME_SUS_PWR_ACK: R103.1 U23.68
ME_SUS_PWR_ACK_R: R102.1 R103.2 R109.1 U14.AV4
MEM_VDD_CTL: TP31.1 U13.B2
MEM_VREF_CTL: TP32.1 U13.C5
MODPHY_EN: PR14.1 U14.Y2
MX0: C392.1 CN16.1 U23.58
MX1: C391.1 CN16.2 U23.59
MX2: C388.1 CN16.5 U23.60
MX3: C387.1 CN16.6 U23.61
MX4: C386.1 CN16.7 U23.62
MX5: C385.1 CN16.8 U23.63
MX6: C383.1 CN16.10 U23.64
MX7: C382.1 CN16.11 U23.65
MY0: C390.1 CN16.3 U23.36
MY1: C389.1 CN16.4 U23.37
MY2: C384.1 CN16.9 CN16.25 U23.38
MY3: C381.1 CN16.12 U23.39
MY4: C380.1 CN16.13 U23.40
MY5: C379.1 CN16.14 U23.41
MY6: C378.1 CN16.15 U23.42
MY7: C377.1 CN16.16 U23.43
MY8: C376.1 CN16.17 U23.44
MY9: C375.1 CN16.18 U23.45
MY10: C374.1 CN16.19 U23.46
MY11: C373.1 CN16.20 U23.51
MY12: C372.1 CN16.21 U23.52
MY13: C371.1 CN16.22 U23.53
MY14: C370.1 CN16.23 U23.54
MY15: C369.1 CN16.24 U23.55
N12E_SCL: R97.1 U13.C9
N12E_SDA: R96.1 U13.C8
NB_MUTE#: R444.1 U10.47 U23.84
NC_H6: U13.H6
NC_J6: U13.J6
NC_J7: U13.J7
NC_K7: U13.K7
NC_M7: U13.M7
NC_N7: U13.N7
NC_P6: U13.P6
NC_R6: U13.R6
NC_R7: U13.R7
NC_T7: U13.T7
NC_V7: U13.V7
NC_W5: U13.W5
NC_W6: U13.W6
NC_W7: U13.W7
NC_Y6: U13.Y6
NFC_IRQ_R: R345.1 U14.AN3
NOA_RCOMP: R325.2 U14.V63
NOA_STBN_0: TP28.1 U14.AA62
NOA_STBN_1: TP23.1 U14.U63
NOA_STBP_0: TP27.1 U14.AA61
NOA_STBP_1: TP21.1 U14.U62
NV_PLLVDD: C137.2 C139.2 L10.1 U13.L6
NV_PWG: R99.1 U13.D10
PANEL_HPD_R: R517.1 R518.1 U25.11
PBAT_PRES#: PC171.2 PQ5.5 PR28.1 PR205.2 R465.2
PCH_EDM: R387.2 U14.AV2
PCH_INTVRMEN: R392.1 R407.2 U14.AV7
PCH_JTAG_TDO: R67.2 U14.AE61
PCH_JTAGX: R346.1 R347.2 U14.AE63
PCH_MELOCK: R395.1 U23.85
PCH_OPIRCOMP: R397.1 U14.AW15
PCH_SATA_LED#: C1.2 LED3.1 R51.1 U14.U3
PCH_SLP_WLAN#: TP51.1 U14.AM5
PCH_SMB_ALERT#: R333.2 RP19.3 U14.AN2
PCH_SPI_CLK: EC13.1 R456.1 R457.2 U14.AA3
PCH_SPI_CS0#: R179.1 R452.1 U14.Y7
PCH_SPI_CS1#: R176.1 U14.Y4
PCH_SPI_SI: R460.1 R463.2 U14.AA2
PCH_SPI_SO: R186.2 R458.1 U14.AA4
PCH_THRMTRIP#: R12.1 U14.D60
PCI_PME_N: TP48.1 U14.AD4
PCIE_CLK_REQ0#: RN1.1 U14.U2
PCIE_CLK_REQ1#: R230.2 RN1.3 U14.Y5
PCIE_CLK_REQ2#: Q42.1 R446.1 RN1.5 U14.AD1
PCIE_CLK_REQ3#: Q45.6 R501.1 RN1.7 U14.N1
PCIE_CLK_REQ3#_R_L: Q45.2 Q46.3 R500.2
PCIE_CLK_REQ4#: Q9.3 RP17.3 U14.U5
PCIE_CLK_REQ5#: RP17.1 U14.T2
PCIE_CR_WAKE#: Q30.1 R199.2 U9.32
PCIE_EC_WAKE#: Q30.3 Q41.3 U23.33
PCIE_IREF: R19.2 U14.B27
PCIE_LAN_WAKE#: Q41.1 R439.2 U6.21
PCIE_MCARD1_DET#: R323.1 U14.Y3
PCIE_RCOMP: R20.2 U14.A27
PCIE_RXN2: C329.2 U14.F15
PCIE_RXN2_C: C329.1 U9.8
PCIE_RXN3: C216.1 U14.G11
PCIE_RXN3_C: C216.2 U6.18
PCIE_RXN4: CN14.43 U14.F13
PCIE_RXP2: C328.2 U14.G15
PCIE_RXP2_C: C328.1 U9.7
PCIE_RXP3: C214.1 U14.F11
PCIE_RXP3_C: C214.2 U6.17
PCIE_RXP4: CN14.41 U14.G13
PCIE_TXN2: C325.2 U14.B31
PCIE_TXN2_C: C325.1 U9.4
PCIE_TXN3: C213.1 U14.C29
PCIE_TXN3_C: C213.2 U6.14
PCIE_TXN4: C346.1 U14.B29
PCIE_TXN4_C: C346.2 CN14.37
PCIE_TXP2: C324.2 U14.A31
PCIE_TXP2_C: C324.1 U9.3
PCIE_TXP3: C210.1 U14.B30
PCIE_TXP3_C: C210.2 U6.13
PCIE_TXP4: C356.1 U14.A29
PCIE_TXP4_C: C356.2 CN14.35
PCIE_WAKE#_R: R131.1 R134.1 U14.AJ5
PECI_EC: R245.1 U23.117
PECI_EC_R: R245.2 U14.N62
PEG_RXN0: C28.2 U14.F10
PEG_RXN0_C: C28.1 U13.AB9
PEG_RXN1: C24.2 U14.F8
PEG_RXN1_C: C24.1 U13.AC10
PEG_RXN2: C14.2 U14.H10
PEG_RXN2_C: C14.1 U13.AC11
PEG_RXN3: C7.2 U14.E6
PEG_RXN3_C: C7.1 U13.AB12
PEG_RXP0: C27.2 U14.E10
PEG_RXP0_C: C27.1 U13.AC9
PEG_RXP1: C25.2 U14.E8
PEG_RXP1_C: C25.1 U13.AB10
PEG_RXP2: C20.2 U14.G10
PEG_RXP2_C: C20.1 U13.AD11
PEG_RXP3: C10.2 U14.F6
PEG_RXP3_C: C10.1 U13.AC12
PEG_TXN0: C413.2 U14.C23
PEG_TXN0_C: C413.1 U13.AG7
PEG_TXN1: C408.2 U14.B23
PEG_TXN1_C: C408.1 U13.AE7
PEG_TXN2: C404.2 U14.B21
PEG_TXN2_C: C404.1 U13.AF9
PEG_TXN3: C402.2 U14.B22
PEG_TXN3_C: C402.1 U13.AG10
PEG_TXP0: C416.2 U14.C22
PEG_TXP0_C: C416.1 U13.AG6
PEG_TXP1: C410.2 U14.A23
PEG_TXP1_C: C410.1 U13.AF7
PEG_TXP2: C405.2 U14.C21
PEG_TXP2_C: C405.1 U13.AE9
PEG_TXP3: C403.2 U14.A21
PEG_TXP3_C: C403.1 U13.AG9
PEGX_RST#: Q39.2 R30.2 R49.2 R50.2 U1.4
PEQ: R509.1 R512.1 U25.4
PEX_CLKREQ#: Q8.2 R35.1 U13.AC6
PEX_PLLVDD: C4.1 C22.1 C43.2 L1.1 U13.AA14 U13.AA15
PEX_TERMP: R285.2 U13.AF25
PEX_TSTCLK: R286.2 U13.AF22
PEX_TSTCLK#: R286.1 U13.AE22
PGOOD: PR89.2 PU4.23
PIRQ_GPIO77: R40.1 U14.U6
PIRQ_GPIO78: TP67.1 U14.P4
PIRQ_GPIO79: TP68.1 U14.N4
PIRQ_GPIO80: R308.1 U14.N2
PLTRST#: CN14.52 R135.2 R229.2 R433.1 U1.2 U14.AG7 U15.1 U15.2
PM_BATLOW#: R122.1 U14.AN4
PM_TEST_RST_N: TP49.1 U14.AC4
PORTD_FS: U7.24 U10.48
POWER_SW_IN0#: C349.1 CN16.29 D7.3 G1.1 G2.2
PRE: R83.1 R87.2 U2.16
PROC_DETECT#: TP38.1 U14.D61
PROC_OPI_COMP: R402.1 U14.AY15
PS8330_RST#: C536.1 R513.2 U25.35
PS_FB_CLAMP: PD1.1 R71.2 R335.1 R434.2 U13.F3
PS_FB_CLAMP_R: R434.1 U23.18
PWR_LED#_R: LED1.2 R1.1
R_SPK+: L26.2 U10.44
R_SPK+_R: C498.2 CN10.6 L26.1
R_SPK-: L27.2 U10.43
R_SPK-_R: C503.2 CN10.5 L27.1
REG_OUT: L22.1 U6.24
REGN_LDO: PC48.1 PD2.2 PR96.1 PR104.1 PR115.1 PU3.16
REM_DIODE1_N: C114.2 C191.2 Q7.1 U3.3
REM_DIODE1_P: C114.1 C191.1 Q7.2 Q7.3 U3.2
REXT: R503.1 U25.7
ROM_CS: TP12.1 U13.D12
ROM_SCLK: R100.1 R101.2 U13.C12
ROM_SI: R401.2 R413.1 U13.B12
ROM_SO: R400.2 R412.1 U13.A12
RREF: R219.2 U9.9
RSMRST#: R390.2 R404.1 U14.AW6 U23.80
RSVD_PGDMON: R106.1 U14.AL11
RT8240BST: PR128.2 PU8.4
RT8240DH: PQ23.4 PU8.3
RT8240DL: PQ28.4 PU8.1
RT8240EN: PC102.1 PR134.1 PR136.1 PU8.8
RT8240FB: PR7.2 PR124.1 PU8.6
RT8240ILIM: PR149.2 PU8.10
RT8240LX: PC98.1 PL1.1 PQ23.1 PQ23.2 PQ23.3 PQ28.5 PR135.2 PU8.2
RT8240RGND: PR130.1 PU8.7
RT8240TON: PR148.1 PR150.2 PU8.11
RT8240VCC: PC84.2 PR1.2 PU8.5
RTC_RST#: C190.1 Q47.3 R119.1 U14.AU7
RTC_X1: C457.2 R385.1 U14.AW5 Y3.1
RTC_X2: C458.2 R385.2 U14.AY5 Y3.2
RUN_ENABLE_1: PR116.2 PU6.10
RUN_ENABLE_2: PR71.2 PU6.11
RUN_ENABLE_3: PR15.2 PU6.12
RUN_ON: PR41.1 PR129.2 PU6.2 PU6.3 PU6.4 U23.123
SATA_IREF: R288.1 U14.A12
SATA_R_LED1: LED3.2 R3.1
SATA_RCOMP: R294.1 U14.C12
SATA_RXN1: C364.1 U14.J8
SATA_RXN1_C: C364.2 CN17.5
SATA_RXP1: C365.1 U14.H8
SATA_RXP1_C: C365.2 CN17.6
SATA_TXN1: C363.1 U14.A17
SATA_TXN1_C: C363.2 CN17.3
SATA_TXP1: C362.1 U14.B17
SATA_TXP1_C: C362.2 CN17.2
SD_CD#: CN9.4 U9.30
SD_CLK: C524.1 CN9.7 U9.17
SD_CMD: CN9.3 U9.19
SD_D0: CN9.9 U9.16
SD_D1: CN9.10 U9.15
SD_D2: CN9.1 U9.21
SD_D3: CN9.2 U9.20
SD_WP: CN9.11 U9.29
SDIO_CK: RP3.4 U14.E3
SDIO_CMD: RP3.2 U14.F4
SDIO_D0: R299.1 R300.2 U14.D3
SDIO_D1: RP1.4 U14.E4
SDIO_D2: RP1.2 U14.C3
SDIO_D3: R298.1 U14.E2
SENSE_A: R261.2 R526.2 U10.13
SENSE_COMBO: C523.1 CN12.5 R261.1
SENSE_JACK: Q48.3 R526.1
SENSOR_HUB_INT: R84.1 U14.AH4
SENSOR_STANDBY_N: R297.1 U14.C4
SIO_EXT_SCI#: D11.2 R352.1 U14.AM2
SIO_PWRBTN#: D20.2 R121.1 U14.AL7
SIO_RCIN#: D21.2 R53.1 U14.V4
SIO_SLP_S3#: PR32.1 R142.1 U14.AT4 U23.124
SIO_SLP_S4#: PR66.2 Q19.2 U14.AJ6 U23.19
SIO_SLP_S5#: D15.2 U14.AP5
SIO_SLP_S5#_R: D15.1 R459.2
SIO_WAKE_SCI#: R124.1 U14.AN5
SLATE_MODE_HALL_IN: R125.1 U14.AL4
SLP_S0#: R183.2 U14.AF3
SLP_S0#_R: R182.1 R183.1 U23.20
SM_INTRUDER#: R120.2 U14.AU6
SM_RCOMP_0: R112.2 U14.AU60
SM_RCOMP_1: R111.2 U14.AV60
SM_RCOMP_2: R110.2 U14.AU61
SM_VREF_CA: R198.2 U14.AP49
SM_VREF_DQ1: R152.2 U14.AP51
SMB3_CLK2_Q: Q15.4 RP8.1 U4.8
SMB3_CLK_Q: Q17.4 RP9.1 U3.8
SMB3_DATA2_Q: Q15.1 RP8.3 U4.7
SMB3_DATA_Q: Q17.1 RP9.3 U3.7
SMB_CLK0: RP21.3 U14.AN1
SMB_CLK_ME1: Q37.4 RP23.3 U14.AU3
SMB_DAT0: RP21.1 U14.AK1
SMB_DATA_ME1: Q37.1 RP23.1 U14.AH3
SMB_INT#: CN15.7 R329.1 R333.1
SMB_PCH_CLK: JDIM1.202 Q34.4 R248.1 RP22.1
SMB_PCH_DAT: JDIM1.200 Q34.1 R249.1 RP22.3
SMBCLK: Q34.3 RP20.3 U14.AP2
SMBCLK0: ESD6.4 PR70.2 PR203.2 RP10.3 U23.110
SMBCLK1: Q37.3 RP11.1 U23.115
SMBCLK3: Q14.3 Q15.3 Q17.3 R172.2 RP12.3 U23.94
SMBDAT0: ESD6.3 PR83.2 PR202.2 RP10.1 U23.111
SMBDAT1: Q37.6 RP11.3 U23.116
SMBDAT3: Q14.6 Q15.6 Q17.6 R169.2 RP12.1 U23.95
SMBDATA: Q34.6 RP20.1 U14.AH1
SMC: CN18.5 PR203.1
SMC_EXTSMI_N: D5.2 R318.1 U14.V1
SMD: CN18.6 PR202.1
SNR_HUB_EN: R81.1 U14.AG3
SNSR_HUB_RST_ACCEL_DRDY_N: R336.1 U14.AK4
SP_PLLVDD: C103.2 C104.2 C110.2 C111.2 L9.2 U13.M6 U13.N6
SPI_CLK: R456.2 U21.6
SPI_CS#: R452.2 U21.1
SPI_SI: R460.2 U21.5
SPI_SO: R458.2 U21.2
SRN: PR63.2 PU3.12
SRP: PR62.1 PU3.13
SRTC_RST#: C450.1 R405.1 U14.AV6
STRAP0: R355.2 R356.1 U13.D1
STRAP1: R361.2 R362.1 U13.D2
STRAP2: R342.2 R343.1 U13.E4
STRAP3: R348.2 R349.1 U13.E3
STRAP4: R364.2 U13.D3
SUB_GND: C343.1 C350.1 C351.2 C394.1 R250.2 R273.1 U12.7 U12.9
SUB_MUTE#: D19.2 R277.2 U12.1
SUB_OUT: C358.1 U10.37
SUB_OUT+: C519.1 CN10.1 L31.2
SUB_OUT+_L: Q25.3 U12.5
SUB_OUT+_MOS: L31.1 Q25.1
SUB_OUT-: C512.1 CN10.2 L30.2
SUB_OUT-_L: Q31.3 U12.8
SUB_OUT-_MOS: L30.1 Q31.1
SUB_PD#_EC: D19.1 Q24.2 U23.118
SUS_ENABLE: PR207.2 PU6.9
SUS_ON: PR82.2 PR134.2 PU6.1 R254.1 R255.2 U23.100
SUSACK#_R: R109.2 U14.AK2
SYS_PWR_SW#: C398.1 D7.2 R279.1 U23.125
SYS_PWROK: R324.1 U23.57
SYS_PWROK_R: R324.2 R327.1 U14.AG2
SYS_RESET#: R331.1 U14.AC3
SYS_SHDN#: Q13.1 R115.2 U3.4
T_WLAN: R483.1 RT1.2 U23.73
TD_IREF: R289.1 U14.B12
TESTLOW_0: RP13.3 U14.C35
TESTLOW_1: RP13.1 U14.C34
TESTLOW_2: RP7.3 U14.AK8
TESTLOW_3: RP7.1 U14.AL8
TESTMODE: R284.1 U13.AD9
THERM_ALERT#: R139.2 U3.6
THERM_STP#: Q13.3 R160.1
THERMAL_STP#_CTRL: R132.2 U14.L4
TOUCH_PANEL_INTR#: R305.1 U14.K2
TOUCHPANEL_EN: R39.1 U14.N7
TP_DC_TEST_A4: TP56.1 U14.A4
TP_DC_TEST_A62: TP41.1 U14.A62
TP_DC_TEST_AV1: TP54.1 U14.AV1
TP_DC_TEST_AW1: TP52.1 U14.AW1
TP_DC_TEST_AW63: TP64.1 U14.AW63
TP_DC_TEST_AY60: TP65.1 U14.AY60
TP_DC_TEST_B2: TP57.1 U14.B2
TP_SMB_RUN_CLK: CN15.6 R248.2 R478.2
TP_SMB_RUN_DAT: CN15.5 R249.2 R477.2
TPCLK: L18.1 R269.1 U23.89
TPCLK-1: C361.2 CN15.2 L18.2
TPDATA: L17.1 R259.1 U23.90
TPDATA-1: C344.2 CN15.3 L17.2
TPM_LPC_PD: TP50.1 U14.AG4
TPSCR_EN: CN11.20 U23.108
TRA_V_DAC: C207.2 U19.3 U19.4 U19.9 U19.10
URAT1_CTS: RP5.4 U14.J4
URAT1_RST: RP6.4 U14.J3
URAT1_RX: RP6.2 U14.K4
URAT1_TX: RP5.2 U14.G2
USB2_CAM1_PWR_EN: R365.1 U14.AM4
USB3.0_RD_EN: R338.1 U14.AP1
USB3.0_RX1+: CN4.6 EU3.2 EU3.9 U14.H20
USB3.0_RX1-: CN4.5 EU3.1 EU3.10 U14.G20
USB3.0_RX2+: CN6.6 EU1.2 EU1.9 U14.F18
USB3.0_RX2-: CN6.5 EU1.1 EU1.10 U14.E18
USB3.0_RX3+: CN5.6 EU2.2 EU2.9 U14.F17
USB3.0_RX3-: CN5.5 EU2.1 EU2.10 U14.G17
USB3.0_TX1+: C205.1 U14.B34
USB3.0_TX1+_C: C205.2 CN4.9 EC34.2 EU3.5 EU3.6
USB3.0_TX1-: C206.1 U14.C33
USB3.0_TX1-_C: C206.2 CN4.8 EC33.2 EU3.4 EU3.7
USB3.0_TX2+: C171.1 U14.A33
USB3.0_TX2+_C: C171.2 CN6.9 EC36.2 EU1.5 EU1.6
USB3.0_TX2-: C174.1 U14.B33
USB3.0_TX2-_C: C174.2 CN6.8 EC35.2 EU1.4 EU1.7
USB3.0_TX3+: C200.1 U14.C31
USB3.0_TX3+_C: C200.2 CN5.9 EC38.2 EU2.5 EU2.6
USB3.0_TX3-: C198.1 U14.C30
USB3.0_TX3-_C: C198.2 CN5.8 EC37.2 EU2.4 EU2.7
USB_BACK_EN: U18.5 U23.31
USB_BIAS: R105.1 U14.AJ10 U14.AJ11
USB_CHG_DET#: CN6.10 D4.3
USB_CHG_DET#_EC: D4.2 R175.1 U23.67
USB_LEFT_EN: R344.1 U14.AT3 U16.4
USB_MCARD1_DET#: R48.1 U14.U4
USB_OC0#: R88.1 U14.AL3 U16.5
USB_OC1#: R350.1 U14.AT1 U17.5 U18.13
USB_OC2#: R332.1 U14.AH2
USB_RIGHT_EN: R388.1 U14.AV3 U17.4
USBP0+: EL8.4 U14.AM8
USBP0+_C: CN4.3 EL8.3 ESD3.1
USBP0-: EL8.1 U14.AN8
USBP0-_C: CN4.2 EL8.2 ESD3.3
USBP0_BUS_SW_CB0: U18.6 U23.56
USBP1+: U14.AT7 U18.3
USBP1+_C: CN6.3 EL7.2 ESD2.3
USBP1+_R: EL7.1 U18.10
USBP1-: U14.AR7 U18.2
USBP1-_C: CN6.2 EL7.3 ESD2.1
USBP1-_R: EL7.4 U18.11
USBP2+: EL6.4 U14.AP8
USBP2+_C: CN5.3 EL6.3 ESD1.3
USBP2-: EL6.1 U14.AR8
USBP2-_C: CN5.2 EL6.2 ESD1.1
USBP3+: R475.1 U14.AT10
USBP3+_R_FT: CN8.2 R475.2
USBP3-: R472.1 U14.AR10
USBP3-_R_FT: CN8.3 R472.2
USBP4+: L5.3 U14.AL15
USBP4+_CN: CN1.5 L5.4
USBP4-: L5.2 U14.AM15
USBP4-_CN: CN1.6 L5.1
USBP5+: L32.2 U14.AN13
USBP5+_TOUCH: CN11.17 L32.1
USBP5-: L32.3 U14.AM13
USBP5-_TOUCH: CN11.18 L32.4
USBP6+: CN14.3 U14.AN11
USBP6-: CN14.5 U14.AP11
USBP7+: L4.3 U14.AP13
USBP7+_TSCR: CN1.2 L4.4
USBP7-: L4.2 U14.AR13
USBP7-_TSCR: CN1.3 L4.1
USBPLLMON_N: R108.1 U14.AN10
USBPLLMON_P: R107.1 U14.AM10
VCHGR_ACDET: PC58.2 PR87.1 PR94.2 PU3.6
VCHGR_BST: PD2.1 PR72.1 PU3.17
VCHGR_DH: PQ43.4 PU3.18
VCHGR_DL: PQ42.4 PU3.15
VCHGR_LX: PC54.1 PC56.1 PL7.1 PQ42.5 PQ42.6 PQ42.7 PQ42.8 PQ43.1 PQ43.2 PQ43.3 PU3.19
VCHGR_PG: PQ16.5 PR96.2 PU3.5
VCHGR_VCC: PC64.1 PR103.2 PU3.20
VCORE_AGND: PC107.2 PC113.2 PC136.2 PC137.2 PR13.1 PR16.2 PR17.2 PR18.2 PR159.2 PR169.2 PR170.2 PR171.2 PU9.22 SJ1.2
VGA_OVT#: Q39.1 R94.1 U13.A6
VGA_PWR_LEVEL: PR178.1 Q16.3 R372.1 U13.D7
VGA_PWR_LEVEL_EC: Q16.2 U23.32
VGA_RST#: C30.1 R30.1 U13.AC7
VGA_THERMDN: C147.2 U4.3 U13.E12
VGA_THERMDP: C147.1 U4.2 U13.F12
VGPU_CORE_SENSE: PR31.2 PR192.1 U13.F2
VMA_CLKN0: R378.1 U13.D25 VRAM2.K7 VRAM4.K7
VMA_CLKN1: R23.1 U13.M22 VRAM1.K7 VRAM3.K7
VMA_CLKP0: R378.2 U13.D24 VRAM2.J7 VRAM4.J7
VMA_CLKP1: R23.2 U13.N22 VRAM1.J7 VRAM3.J7
VMA_CMD0: U13.C27 VRAM2.L2 VRAM4.L2
VMA_CMD1: TP63.1 U13.C26
VMA_CMD2: R86.2 U13.E24 VRAM2.K1 VRAM4.K1
VMA_CMD3: R369.2 U13.F24 VRAM2.K9 VRAM4.K9
VMA_CMD4: U13.D27 VRAM1.T7 VRAM2.T7 VRAM3.T7 VRAM4.T7
VMA_CMD5: R341.1 U13.D26 VRAM1.T2 VRAM2.T2 VRAM3.T2 VRAM4.T2
VMA_CMD6: U13.F25 VRAM1.R3 VRAM2.R3 VRAM3.R3 VRAM4.R3
VMA_CMD7: U13.F26 VRAM1.R2 VRAM2.R2 VRAM3.R2 VRAM4.R2
VMA_CMD8: U13.F23 VRAM1.P3 VRAM2.P3 VRAM3.P3 VRAM4.P3
VMA_CMD9: U13.G22 VRAM1.N3 VRAM2.N3 VRAM3.N3 VRAM4.N3
VMA_CMD10: U13.G23 VRAM1.P8 VRAM2.P8 VRAM3.P8 VRAM4.P8
VMA_CMD11: U13.G24 VRAM1.P7 VRAM2.P7 VRAM3.P7 VRAM4.P7
VMA_CMD12: U13.F27 VRAM1.M2 VRAM2.M2 VRAM3.M2 VRAM4.M2
VMA_CMD13: U13.G25 VRAM1.L3 VRAM2.L3 VRAM3.L3 VRAM4.L3
VMA_CMD14: U13.G27 VRAM1.M7 VRAM2.M7 VRAM3.M7 VRAM4.M7
VMA_CMD15: U13.G26 VRAM1.K3 VRAM2.K3 VRAM3.K3 VRAM4.K3
VMA_CMD16: U13.M24 VRAM1.L2 VRAM3.L2
VMA_CMD17: TP46.1 U13.M23
VMA_CMD18: R303.1 U13.K24 VRAM1.K1 VRAM3.K1
VMA_CMD19: R27.1 U13.K23 VRAM1.K9 VRAM3.K9
VMA_CMD20: U13.M27 VRAM1.T3 VRAM2.T3 VRAM3.T3 VRAM4.T3
VMA_CMD21: U13.M26 VRAM1.T8 VRAM2.T8 VRAM3.T8 VRAM4.T8
VMA_CMD22: U13.M25 VRAM1.R8 VRAM2.R8 VRAM3.R8 VRAM4.R8
VMA_CMD23: U13.K26 VRAM1.R7 VRAM2.R7 VRAM3.R7 VRAM4.R7
VMA_CMD24: U13.K22 VRAM1.P2 VRAM2.P2 VRAM3.P2 VRAM4.P2
VMA_CMD25: U13.J23 VRAM1.N2 VRAM2.N2 VRAM3.N2 VRAM4.N2
VMA_CMD26: U13.J25 VRAM1.M3 VRAM2.M3 VRAM3.M3 VRAM4.M3
VMA_CMD27: U13.J24 VRAM1.N8 VRAM2.N8 VRAM3.N8 VRAM4.N8
VMA_CMD28: U13.K27 VRAM1.N7 VRAM2.N7 VRAM3.N7 VRAM4.N7
VMA_CMD29: U13.K25 VRAM1.L7 VRAM2.L7 VRAM3.L7 VRAM4.L7
VMA_CMD30: U13.J27 VRAM1.J3 VRAM2.J3 VRAM3.J3 VRAM4.J3
VMA_CMD31: TP62.1 U13.J26
VMA_DM0: U13.D19 VRAM2.D3
VMA_DM1: U13.D14 VRAM2.E7
VMA_DM2: U13.C17 VRAM4.D3
VMA_DM3: U13.C22 VRAM4.E7
VMA_DM4: U13.P24 VRAM1.D3
VMA_DM5: U13.W24 VRAM1.E7
VMA_DM6: U13.AA25 VRAM3.D3
VMA_DM7: U13.U25 VRAM3.E7
VMA_DQ0: U13.E18 VRAM2.A3
VMA_DQ1: U13.F18 VRAM2.C3
VMA_DQ2: U13.E16 VRAM2.A2
VMA_DQ3: U13.F17 VRAM2.C2
VMA_DQ4: U13.D20 VRAM2.A7
VMA_DQ5: U13.D21 VRAM2.D7
VMA_DQ6: U13.F20 VRAM2.C8
VMA_DQ7: U13.E21 VRAM2.B8
VMA_DQ8: U13.E15 VRAM2.F8
VMA_DQ9: U13.D15 VRAM2.F7
VMA_DQ10: U13.F15 VRAM2.H8
VMA_DQ11: U13.F13 VRAM2.H7
VMA_DQ12: U13.C13 VRAM2.G2
VMA_DQ13: U13.B13 VRAM2.E3
VMA_DQ14: U13.E13 VRAM2.H3
VMA_DQ15: U13.D13 VRAM2.F2
VMA_DQ16: U13.B15 VRAM4.D7
VMA_DQ17: U13.C16 VRAM4.A7
VMA_DQ18: U13.A13 VRAM4.C8
VMA_DQ19: U13.A15 VRAM4.B8
VMA_DQ20: U13.B18 VRAM4.A2
VMA_DQ21: U13.A18 VRAM4.C2
VMA_DQ22: U13.A19 VRAM4.A3
VMA_DQ23: U13.C19 VRAM4.C3
VMA_DQ24: U13.B24 VRAM4.G2
VMA_DQ25: U13.C23 VRAM4.E3
VMA_DQ26: U13.A25 VRAM4.H3
VMA_DQ27: U13.A24 VRAM4.F2
VMA_DQ28: U13.A21 VRAM4.F7
VMA_DQ29: U13.B21 VRAM4.F8
VMA_DQ30: U13.C20 VRAM4.H7
VMA_DQ31: U13.C21 VRAM4.H8
VMA_DQ32: U13.R22 VRAM1.D7
VMA_DQ33: U13.R24 VRAM1.A7
VMA_DQ34: U13.T22 VRAM1.C8
VMA_DQ35: U13.R23 VRAM1.B8
VMA_DQ36: U13.N25 VRAM1.C3
VMA_DQ37: U13.N26 VRAM1.A2
VMA_DQ38: U13.N23 VRAM1.C2
VMA_DQ39: U13.N24 VRAM1.A3
VMA_DQ40: U13.V23 VRAM1.E3
VMA_DQ41: U13.V22 VRAM1.G2
VMA_DQ42: U13.T23 VRAM1.F2
VMA_DQ43: U13.U22 VRAM1.H3
VMA_DQ44: U13.Y24 VRAM1.H7
VMA_DQ45: U13.AA24 VRAM1.F7
VMA_DQ46: U13.Y22 VRAM1.F8
VMA_DQ47: U13.AA23 VRAM1.H8
VMA_DQ48: U13.AD27 VRAM3.C3
VMA_DQ49: U13.AB25 VRAM3.A3
VMA_DQ50: U13.AD26 VRAM3.A2
VMA_DQ51: U13.AC25 VRAM3.C2
VMA_DQ52: U13.AA27 VRAM3.B8
VMA_DQ53: U13.AA26 VRAM3.A7
VMA_DQ54: U13.W26 VRAM3.D7
VMA_DQ55: U13.Y25 VRAM3.C8
VMA_DQ56: U13.R26 VRAM3.H7
VMA_DQ57: U13.T25 VRAM3.F8
VMA_DQ58: U13.N27 VRAM3.F7
VMA_DQ59: U13.R27 VRAM3.H8
VMA_DQ60: U13.V26 VRAM3.F2
VMA_DQ61: U13.V27 VRAM3.H3
VMA_DQ62: U13.W27 VRAM3.E3
VMA_DQ63: U13.W25 VRAM3.G2
VMA_RDQS0: U13.F19 VRAM2.B7
VMA_RDQS1: U13.C14 VRAM2.G3
VMA_RDQS2: U13.A16 VRAM4.B7
VMA_RDQS3: U13.A22 VRAM4.G3
VMA_RDQS4: U13.P25 VRAM1.B7
VMA_RDQS5: U13.W22 VRAM1.G3
VMA_RDQS6: U13.AB27 VRAM3.B7
VMA_RDQS7: U13.T27 VRAM3.G3
VMA_WDQS0: U13.E19 VRAM2.C7
VMA_WDQS1: U13.C15 VRAM2.F3
VMA_WDQS2: U13.B16 VRAM4.C7
VMA_WDQS3: U13.B22 VRAM4.F3
VMA_WDQS4: U13.R25 VRAM1.C7
VMA_WDQS5: U13.W23 VRAM1.F3
VMA_WDQS6: U13.AB26 VRAM3.C7
VMA_WDQS7: U13.T26 VRAM3.F3
VMA_ZQ1: R85.2 VRAM2.L8
VMA_ZQ2: R368.2 VRAM4.L8
VMA_ZQ3: R31.2 VRAM1.L8
VMA_ZQ4: R302.2 VRAM3.L8
VR_READY: C197.1 D1.1 R15.2 R18.2 R491.2 U14.C59
VR_SVID_ALERT#: PR138.2 R312.2 R313.2 R321.2
VR_SVID_CLK: PR142.2 U14.N63
VR_SVID_DATA: PR137.2 R316.2 R320.2 U14.L63
VREF: C332.1 C338.2 U10.25
VREFC_VMA1: C440.1 R360.1 R366.2 VRAM2.M8 VRAM4.M8
VREFC_VMA3: C37.1 R41.2 R47.1 VRAM1.M8 VRAM3.M8
VREFD_VMA1: C170.1 R89.1 R93.2 VRAM2.H1 VRAM4.H1
VREFD_VMA3: C420.1 R296.2 R301.1 VRAM1.H1 VRAM3.H1
VREFF_CA_A: C298.2 R198.1 R202.1
VREFOUT_AL: R267.2 U10.23
WLAN_CLKREQ#: CN14.53 Q46.5 R225.1 R501.2
WLAN_EC_PWR_EN#: Q27.2 U23.78
WLAN_EC_WAKE#: SJ2.2 U23.104
WLAN_ON/OFF#: Q23.1 R218.1 U14.AT5
WLAN_ON/OFF#_R: CN14.56 Q23.3 R218.2 R236.1
WLAN_WAKE#: Q21.3 SJ2.1
WLAN_WAKE#_R: CN14.55 Q21.1 R197.1
WOOFER_EN: C393.2 Q24.3 Q25.2 Q31.2 R246.2
WRST#: C502.1 R468.1 U23.14
XDP_TCK0: R10.1 R347.1 U14.E60
XDP_TCK1: R351.2 U14.AE62
XDP_TDI: R63.2 U14.AD61
XDP_TDO_CPU: R33.1 U14.F62
XDP_TMS: R340.2 U14.AD62
XDP_TRST_CPU_N: R353.1 U14.AU62 U14.E59
XTAL24_IN: C422.1 R292.1 U14.A25 Y1.3
XTAL24_OUT: C423.1 R292.2 U14.B25 Y1.1
XTAL_SSIN: R381.1 U13.A10
N20714548: CN16.26 R274.1
N23727870: C345.2 C354.2 R258.1
N30510538: JDIM1.198 R203.1
N77718867: Q13.2 R128.1 R132.1 R138.2
N93290362: Q35.1 Q38.3
N106078187: R471.2 U24.3
N106078293: R473.2 U24.7
N106078316: R462.2 U21.3
N106078324: R451.2 U21.7
N122930874: TP53.1 U14.AP4
N123894080: R21.1 U14.C26
N124584583: C521.2 Q28.2 R239.1 R479.2
N124584682: Q26.2 R235.2 R238.2
N126037216: C116.2 R56.2 U14.Y8
N128064339: D12.2 U23.21
N128064405: D11.1 U23.23
N128064409: D21.1 U23.4
N128064579: C504.2 U23.12
N128064904: C491.1 L25.1 U23.75
N128065097: R459.1 U23.76
N128065099: R465.1 U23.77
N128065117: D20.1 U23.81
N128622958: R95.1 U2.12
N128622966: R363.1 U2.15
N128623205: R72.2 U2.18
N128623427: R75.2 R82.2 U2.36
N128983961: EC6.1 R223.1
N129561392: R419.2 U18.7 U18.8
N129561428: R430.2 U18.16
N129841983: C212.1 R146.2 R148.2 U5.5
N129843308: R141.2 R142.2 R143.2 U5.2
N129844102: Q18.3 R154.2
N129885414: R188.2 U9.28
N129957604: C298.1 R207.2
N129964663: C215.1 R153.2
N130076878: C342.1 Q27.3 Q29.3 R244.1
N130191757: Q40.5 Q40.6 R414.1
N130315674: D5.1 U23.15
N130323284: Q19.5 Q19.6 R155.2
N130397772: R429.2 U18.15
N130398206: R420.2 R421.2 U18.4
N130449913: R293.2 U14.B8
N130831290: C355.1 U10.21
N130831312: C273.2 U10.1
N130831320: R231.2 U10.7
N130831363: C304.2 C494.1 R461.2 U10.3
N130831369: R266.1 U10.22
N130831515: C289.2 U10.34
N131133774: Q20.6 R172.1 R466.2
N131135141: Q20.3 R169.1 R484.2
N131184695: R329.2 U14.U7
N131237173: R441.1 U6.31
N131663614: Q4.3 R4.1
N131663616: PR14.2 Q3.5 R6.2 R7.1
N131663662: Q3.2 Q3.3 Q4.2 Q5.2 R11.1
N131663684: Q5.3 R5.1
N131663741: PC8.1 PQ1.4 R4.2 R5.2
N131663808: PR12.1 Q3.6
N131687489: PU2.7 PU2.8 R174.2
N131687511: PC42.1 PU2.6
N131800584: R70.2 U13.F6
N131966494: Q26.3 R239.2
N132058185: PC50.2 PQ12.3 PQ13.2 PR78.1
N132058193: PQ14.2 PQ15.3 PR91.1
N132058210: PC181.1 PR199.1
N132058229: PC74.2 PR113.1 PU4.16
N132058301: PR90.2 PU4.18
N132058366: PC179.1 PR198.1
N132058395: PC69.2 PR98.2
N132058414: PR75.2 PR196.2
N132058422: PR69.2 PR194.2
N132058456: PR98.1 PU4.9
N132058503: PC65.1 PR92.1
N132064940: PC55.2 PR77.2 PR81.1 PU5.9
N132064948: PD3.1 PR32.2 PR39.2 PR41.2 PR86.2
N132064968: PC55.1 PR77.1 PR195.1
N132065111: PC182.2 PR200.1
N132066969: PR140.2 PR147.1 PU8.9
N132066980: PR7.1 PR8.2
N132067077: PC98.2 PR128.1
N132067106: PC104.1 PR135.1
N132067112: PD6.1 PR147.2
N132067793: PC89.2 PR127.2 PR133.1 PU7.6
N132067797: PL2.2 PU7.1 PU7.2 PU7.3
N132067872: PC91.1 PR129.1 PU7.5
N132072865: PC51.1 PQ10.3 PR71.1
N132072905: PC14.1 PQ4.4 PR15.1
N132073040: PC82.1 PQ19.3 PR116.1
N132073086: PC37.1 PQ9.3 PR207.1
N132077352: PD1.3 PQ8.2 PR59.1
N132077358: PQ8.3 PR50.2 PR57.2
N132077583: PQ2.2 PQ27.2 PQ34.2 PQ41.3 PR49.1 PR188.2 PR191.1
N132077598: PC158.2 PD7.2 PQ41.2 PR190.1
N132077614: PQ37.3 PR179.2
N132077668: PC79.2 PD4.2 PQ18.2 PR105.2
N132077791: PQ34.3 PR29.2
N132078025: PQ33.3 PR175.2
N132078232: PQ2.3 PR9.2
N132189519: PR35.2 PU1.18
N132189535: PR52.2 PR58.1 PR60.1 PU1.4
N132189539: PC34.1 PR46.2 PR48.1 PU1.7
N132189541: PR55.1 PU1.5
N132189548: PC26.1 PR34.1 PU1.15
N132189552: PR47.2 PR48.2 PR56.1
N132189562: PC27.1 PR37.1 PR177.2 PU1.13
N132189566: PC254.1 PR54.2 PU1.3
N132189568: PR178.2 PR181.2 PU1.14
N132189576: PR56.2 PU1.6
N132189624: PR46.1 PR51.1
N132189878: PC28.2 PR35.1
N132189916: PR42.1 PU1.9
N132189952: PR53.2 PU1.1
N132189956: PC35.2 PR53.1
N132190007: PC32.1 PC166.2 PR44.2 PR192.2
N132190113: PC30.1 PR40.1
N132190141: PC32.2 PR43.2
N132190211: PC150.2 PR184.1
N132190437: PC153.2 PR186.1
N132285438: Q24.5 Q24.6 R220.2
N132286840: R260.2 U12.4
N132286842: C358.2 R260.1
N132286847: R272.2 U12.3
N132286854: C394.2 R272.1
N132292966: PC111.1 PL4.1 PQ24.4
N132293008: PC6.1 PR2.2 PR3.2 PR6.1 PR10.1
N132293024: PC95.1 PL3.1 PQ26.4
N132293060: PC108.1 PR139.2
N132293090: PR167.1 PR169.1 PU9.15
N132293105: PQ24.1 PR161.2
N132293107: PC90.2 PR131.2
N132293124: PC90.1 PQ24.7
N132293126: PQ24.6 PR131.1
N132293132: PC118.2 PC119.2 PL4.4 PR125.1 PR160.2 PR206.2
N132293163: PC111.2 PR158.1
N132293211: PR121.2 PR125.2
N132293406: PQ26.1 PR163.2
N132293412: PC114.2 PR155.2
N132293428: PC114.1 PQ26.7
N132293430: PQ26.6 PR155.1
N132293475: PC95.2 PR120.1
N132293523: PR119.2 PR126.2
N132294519: PR168.2 PU9.16
N132294702: PR159.1 PU9.4
N132313959: PC41.1 PC44.1 PR62.2 PR201.1P
N132314015: PD5.1 PR103.1
N132314297: PC16.1 PC138.2 PQ31.4 PQ32.4 PR173.2 PR174.1
N132314323: PQ6.6 PR25.2 PR26.2 PR27.2
N132314464: PQ31.1 PQ31.2
N132314499: PQ5.3 PQ31.5 PR23.1 PR24.2
N132314535: PR70.1 PU3.9
N132314688: PC17.1 PQ6.5 PR28.2
N132314783: PC16.2 PQ6.3
N132314788: PQ5.6 PR22.2
N132314800: PR83.1 PU3.8
N132314870: PC40.1 PC44.2 PR63.1 PR201.2P
N132314886: PC54.2 PR72.2
N132314946: PC144.1 PQ35.1 PQ35.2 PQ35.3 PR182.2 PR183.1
N132314996: PR111.2 PR193.2
N132315026: PQ35.4 PR180.2 PR182.1
N132315143: PL7.2 PR201.1
N132315213: PC56.2 PR68.1
N132315899: PQ17.6 PR93.1 PR95.1 PR97.2
N132315907: PQ17.5 PR97.1
N132315919: PQ17.2 PR93.2
N132315927: PQ17.1 PR114.1
N132315989: PR64.2 PU3.11
N132479764: TP60.1 U14.J62
N132479767: TP61.1 U14.K62
N132479770: TP58.1 U14.E61
N132479773: TP59.1 U14.F63
N133154508: PL3.3 PR123.1
N133154903: PL4.3 PR122.1
N133155498: PC240.1 PQ50.6 PR426.2
N133155504: PC240.2 PQ50.5 PR427.1
N133155524: PD8.2 PQ901.1
N133155526: PQ50.2 PQ901.3 PR425.1
N133155528: PQ901.2 PR424.2
N133159595: PQ22.3 PR118.2
N133161663: PC241.1 PQ21.2 PR428.2
N133194593: Q44.3 R481.2
N133195216: Q44.5 Q44.6 R482.1
N134397230: U7.36 U7.37
N134397236: U7.1 U7.2
N134397258: U7.13 U7.14
N134549402: PR432.2 PR434.2 PU11.4
N134912471: R504.1 U25.10

Pads without a net: CN1 14 15 16 18; CN3 13 14; CN8 4 6; CN10 7 8; CN11 26; CN14 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 50 58 59 60 61 62 65 67; CN15 8 9 10; CN16 30 31 32; CN17 8 9 18 20 21 22 23 24; CN18 4; ESD1 4 6; ESD2 4 6; ESD3 4 6; ESD6 1; FAN1 5 6; FAN2 5 6; JDIM1 77 122 125; PU5 7; PU6 5 6 7 8 14 15; PU7 7; Q45 3 4 5; Q46 1 2 6; RP19 1; RTCBT1 3 4; U4 4 6; U5 1; U7 10 11 18 19 21 23 25 38 39; U9 13 22 23 24 25 26 31; U10 14 15 19 20 30; U12 2; U13 A3 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB13 AB15 AB16 AB18 AB19 AB21 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B19 C1 C2 C3 C4 C18 D4 D11 D16 D17 D18 E6 E9 E10 F4 F5 F7 F10 F11 G1 G2 G3 G4 G5 G6 G7 H3 H4 J1 J2 J3 J4 J5 K1 K2 K3 K4 K5 K6 L3 L4 M1 M2 M3 M4 M5 N1 N2 N3 N4 N5 P3 P4 R1 R2 R3 R4 R5 T1 T2 T3 T4 T5 T6 T24 U3 U4 U6 U24 V1 V2 V3 V4 V5 V6 V24 V25 W1 W2 W3 W4 Y3 Y4; U14 A5 A6 A8 A15 A35 A37 A49 A53 A60 AA23 AA59 AB21 AB23 AC2 AC20 AC58 AC59 AC63 AD2 AD23 AD59 AD60 AE6 AE59 AE60 AF1 AF2 AF4 AF20 AG58 AH60 AH61 AH62 AH63 AJ7 AJ61 AJ62 AK40 AK42 AK43 AK45 AK46 AK48 AK49 AK51 AK54 AK55 AK57 AK58 AK60 AK61 AK62 AK63 AL1 AL5 AL32 AL42 AL43 AL48 AL49 AL55 AL58 AM7 AM11 AM40 AM42 AM43 AM45 AM46 AM48 AM49 AM51 AM54 AM55 AM57 AM58 AM60 AM61 AM62 AM63 AN54 AN55 AN57 AN58 AN61 AN62 AP7 AP32 AP33 AP35 AP36 AP55 AP58 AP60 AP61 AP62 AP63 AR32 AR35 AR36 AR38 AR51 AR54 AR55 AR57 AR58 AT2 AU4 AU10 AU12 AU15 AU34 AU35 AU36 AU37 AU39 AU40 AU41 AU42 AU43 AU44 AU52 AU54 AU56 AU58 AV10 AV35 AV37 AV40 AV42 AV44 AV50 AV52 AV53 AV54 AV56 AV57 AV58 AV62 AW10 AW14 AW34 AW36 AW39 AW41 AW43 AW49 AW52 AW53 AW54 AW56 AW57 AW58 AY8 AY14 AY34 AY36 AY37 AY39 AY41 AY42 AY43 AY52 AY54 AY56 AY58 B5 B6 B14 B15 B35 B37 B43 B49 B50 B53 B54 C5 C15 C17 C42 C43 C46 C47 C49 C50 C51 C53 D1 D9 D11 D15 D17 D58 E1 E5 E13 E15 F5 F22 H5 H6 H18 H22 H60 H61 H62 H63 J5 J6 J20 J21 J58 J60 J61 K10 K18 K21 K59 K60 L1 L11 L59 M20 M21 N23 N58 N60 P20 R5 R20 R23 T23 T59 U10 U59 V21 V59 W23 Y6 Y20 Y22; U18 9; U25 8 9 13 14 15 16 17 21 26 33 34 37 43 44 45 46 47 48; U* 1; U*#2 1; U*#3 1; U*#4 1; U*#5 1; U*#6 1; VRAM1 J1 J9 L1 L9; VRAM2 J1 J9 L1 L9; VRAM3 J1 J9 L1 L9; VRAM4 J1 J9 L1 L9

## Via types
v1: diameter 0.66, hole 0.33, TOP to BOTTOM, 968 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 3680 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 701 vias
v4: diameter 0.66, hole 0.254, TOP to BOTTOM, 1 via

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.5V_RUN_PWRGD: length 107.1
  TOP w0.102: v2(161.6,115.99) 162.77,117.16 162.77,122.08 v2(163.94,123.25) ; R189.2 182.85,38.69 181.9,39.65 181.9,45.68 v1(182.65,46.43) 187.72,51.5 v2(188.25,51.5)
  IN2 w0.114: v2(161.6,115.99) 161.6,114.69 161.96,114.34 164.22,114.34 165.39,113.17 168.54,113.17 170.29,111.42 170.29,105.4 178.67,97.01 178.67,93.43 180.3,91.81 180.3,88.75 178.47,86.92 178.47,85.04 178.98,84.53 178.98,82.81 178.47,82.29 178.47,81.58 178.09,81.21 178.09,78.5 179.38,77.21 179.38,75.64 181.01,74.02 181.01,74 181.14,73.87 181.14,70.45 181.01,70.32 181.01,69.15 182.54,67.62 182.54,60.2 188.25,54.49 v2(188.25,51.5)
  BOTTOM w0.254: PU7.4 164.36,122.76 163.94,123.19 v2(163.94,123.25)
1.5VGFX_OND: length 59.8
  TOP w0.102: PQ7.4 225.83,74.74 PC18.1 225.5,75.07 224.8,75.07 v2(224.75,75.02) v1(223.86,75.02)
  IN2 w0.114: v2(217.78,119.9) 218.36,119.9 218.61,119.65 221.06,119.65 221.79,120.38 223.57,120.38 225.59,118.36 225.59,90.56 225.86,90.29 225.86,75.8 225.08,75.02 v2(224.75,75.02)
  BOTTOM w0.102: v2(217.78,119.9) PR141.2 217.23,120.64 216.72,121.14 PQ25.3
1.05VGFX_OND: length 27
  TOP w0.102: v2(200.34,110.15) 200.26,110.22 PC15.1
  IN1 w0.089: v2(217.33,118.6) 213.56,118.6 211.71,116.75 211.71,116.67 205.78,110.73 200.92,110.73 v2(200.34,110.15)
  BOTTOM w0.102: v2(217.33,118.6) 217.58,118.35 PQ27.3 219.59,118.35 219.97,118.73 PR151.2 220.7,117.86 v1(220.63,117.79) ; v2(200.34,110.15) 199.91,109.71 PQ30.4
1.5VGFX_OND#: length 105.2
  TOP w0.102: v1(248.01,51.59) PR49.2 246.17,50.53 245.79,50.91 244.82,50.91 244.28,51.46 v2(244.28,51.5) 244.15,51.37 244.15,51.25 PR50.1
  IN2 w0.114: v2(215.17,119.8) 215.73,120.36 218.42,120.36 218.88,119.9 221,119.9 221.7,120.6 223.66,120.6 225.81,118.45 225.81,90.89 226.14,90.56 226.14,88.72 226.73,88.14 226.73,87.31 226.09,86.67 226.09,73.98 228.02,72.05 228.02,69.02 227.85,68.85 v2(227.85,68.31) 227.88,68.28 227.88,67.89 227.88,67.89 227.88,67.51 227.88,62.49 230.54,59.83 239.58,59.83 244.15,55.26 244.15,51.62 v2(244.28,51.5)
  BOTTOM w0.102: v2(215.17,119.8) 215.17,120.31 214.99,120.48 PQ25.2 ; PQ33.2 227.97,70.95 228.2,70.73 228.2,68.67 v2(227.85,68.31)
3.3V_ALW_ON: length 33.9
  TOP w0.102: R162.1 186.43,45.51 185.15,44.23 185.15,39.15 v1(186,38.3) 186.62,37.68 186.62,33.71 186.39,33.48 186.39,33.03 186.9,32.52 186.9,27.98 186.83,27.9 v2(186.83,24.01) ; v2(184.72,18.25) 184.73,18.27 R282.1 185.78,18.27 186.11,17.94 187.81,17.94 187.96,18.08 Q32.3
  BOTTOM w0.102: v2(184.72,18.25) 184.72,19.65 186.83,21.75 v2(186.83,24.01)
3V3AUX:
  vias: v1(54.54,40.75)
3V_FB2: length 4.3
  TOP w0.152: PR69.1 130.82,33.83 130.95,33.95 v1(130.95,34.4)
  TOP w0.254: PR69.1 PR76.1 130.71,32.29 PU4.5
3V_LGATE2: length 8.3
  IN3 w1.016: 128.13,25.29 123.63,20.8 122.43,20.8 122.41,20.81
  BOTTOM w0.254: v2(129.27,26.23) 129.26,26.22 v1(129.26,25.52)
  vias: v2(120.61,20.77) v2(121.27,20.8) v2(128.64,26.23)
3V_PHASE2: length 10.7
  TOP w0.508: 127.98,26.82 127.04,25.88 v1(126.65,25.88) PC69.1
  TOP w0.762: v2(118.68,24.07) v2(119.41,24.07) 119.49,24.07 120.58,25.16 123.66,25.16 123.76,25.06 125.03,25.06 125.47,25.5 PC69.1
3V_UGATE2: length 15.5
  IN3 w0.762: 118.25,20.64 118.22,20.66 118.22,21.2 117.84,21.58 117.84,25.06 119.25,26.46 126.64,26.46 127.16,26.99
  BOTTOM w0.254: v2(127.42,27.3) v1(126.63,27.3)
  vias: v2(117.64,19.91) v2(118.3,19.91) v2(127.9,27.73)
3VGFX_OND: length 6.4
  BOTTOM w0.102: v3(220.53,120.69) 220.56,120.66
  BOTTOM w0.508: 220.56,120.66 222.51,120.66 222.82,120.36 222.82,118.73 222,117.92 PQ29.3
  vias: v1(220.1,121.55) v3(219.69,120.69)
5V_BST1: length 2.9
  TOP w0.279: PU4.22 134.45,28.34 134.66,28.55 v1(135.2,28.55) 135.8,28.55 135.85,28.6 PR92.2
5V_FB1: length 7.4
  TOP w0.102: PR75.1 134.96,32.58 134.96,33.26 135.57,33.87 v1(136.43,33.87)
  TOP w0.254: PU4.2 132.21,30.87 132.47,31.14 133.24,31.14 PR74.1 PR75.1
5V_LGATE1: length 4.6
  IN3 w0.508: v2(137.76,23.47) 137.73,23.49 v2(137.12,23.49) 134.92,25.7 v2(134.92,25.87) 134.92,26.15 v2(134.63,26.44)
  vias: v1(135.57,26.14)
5V_PHASE1: length 7.6
  IN3 w0.508: v2(135.34,27.05) v2(135.98,27.05) 136.51,27.05 138.72,24.84 138.72,23.72 v2(138.9,23.54) 138.95,23.49 v2(139.66,23.49)
  BOTTOM w0.508: PR199.2 139.72,24.75 v1(139.72,25.42)
5V_UGATE1: length 17.2
  IN3 w0.508: v2(134.86,27.83) v2(135.55,27.83) 137.04,27.83 140.78,24.1 140.78,16.86 v2(141.08,16.56) v2(141.77,16.56)
  BOTTOM w0.508: v1(136.67,27.29) 136.13,27.83 v2(135.55,27.83)
+1.1V_DSP: length 1.8
  TOP w0.203: U7.9 265.54,40.5 264.78,39.74
  vias: v1(249.16,42.2) v1(255.41,41.95) v2(254.36,42.66) v2(255.13,42.66) v2(268.03,37.63) v2(268.69,37.63)
+1.05V_GFX: length 72
  TOP w0.508: v2(177.19,89.28) 177.46,89.01 177.5,89.01 178.15,88.37 L10.2 178.42,87.54 177.73,86.85 177.73,84.52 177.38,84.16 177.38,79.77 175.62,78.01 175.62,76.54 176.64,75.53 177.15,75.53 178.29,74.38 178.29,71.08 178.82,70.55 181.14,70.55 181.77,71.18 181.77,72.33 182.43,72.99 182.43,73.5 183.54,74.61 184.06,74.61 184.59,75.14 185.96,75.14 v2(185.99,75.17)
  IN1 w1.016: 196.43,106.97 196.07,106.97 194.19,108.85 191.27,108.85 187.71,105.29 185.17,105.29 182.69,102.81 180.07,102.81 179.81,102.55 178.93,102.55
  IN2 w0.508: v2(175.4,93.41) 175.4,93.25 176.47,92.18 176.47,91.46 177.19,90.75 v2(177.19,89.28) ; v2(202.92,103.4) 204.59,103.4 v2(204.71,103.29)
  BOTTOM w0.102: U13.AA12 191.48,99.76 191.22,99.5 v2(190.99,99.5)
  BOTTOM w0.305: U13.AA10 189.7,100.14 189.7,100.14 v2(189.67,100.16)
  BOTTOM w0.381: v2(204.71,103.29) 204.66,103.24 204.66,103.2 204.45,103 U13.AE27 ; v2(192.16,100.16) 192.16,100.16 U13.AA13
  BOTTOM w0.508: v2(185.99,75.17) 185.49,75.17 R386.2
  BOTTOM w1.016: 177.07,102.35 177.07,95.01 176.18,94.12
  vias: v1(196.4,110.15) v2(175.37,94.04) v2(177.61,103.39) v2(178.04,102.93) v2(194.65,100.16) v2(196.83,105.98) v2(197.12,100.18) v2(197.37,105.62) v2(198.78,100.1) v2(199.63,100.92) v2(199.62,100.1) v2(200.45,101.77) v2(200.41,100.14) v2(200.48,100.9) v2(201.3,102.62) v2(201.27,101.75) v2(202.1,103.42) v2(202.12,102.6) v2(202.9,104.2) v2(203.89,104.53) v3(201.53,112.69) v3(201.56,113.42) v3(201.56,111.92) v3(202.34,113.42) v3(202.34,112.69) v3(202.32,111.96) v3(209.74,117.85) v3(209.74,117.11)
+1.5V_RUN: length 268.7
  TOP w0.508: 251.57,43.83 PC251.1 250.33,43.92 PC250.1 249.1,43.73 PU11.6 ; R95.2 v2(316.37,80)
  TOP w1.016: 153.97,116.58 153.55,116.16 153.55,112.51 153.83,112.23 159.27,112.23 ; 252.48,45.73 252.71,45.96 259.01,45.96 259.19,46.14 260.99,46.14 261.35,46.49 263.54,46.49 265.34,48.3 277.17,48.3 277.6,47.87 277.6,45.71
  IN2 w1.016: 287.77,49.99 290.44,49.99 291.53,48.9 292.96,48.9 294.53,50.47 295.19,50.47 297.48,52.76 297.48,57.48 297.49,57.49 297.49,58.91 300.25,61.67 301.67,61.67 302.87,62.87 302.87,63.6 302.64,63.82 302.64,65.5 303.31,66.18 304.07,66.18 304.71,66.83 308.85,66.83 312.99,70.96 312.99,72.83 ; 169.5,88.58 167.88,90.21 167.27,90.21 166.62,90.86 166.62,91.88 165.41,93.09 164.57,93.09 164.05,93.6 164.05,98.53 161.43,101.15 161.43,103.08 159.43,105.08 159.43,109.22 160.56,110.35 160.56,111.49 ; 251.47,49.59 251.45,49.61 243.81,49.61 241.15,46.95 239.17,46.95 237.61,45.4 231.94,45.4 230.88,46.45 222.53,46.45 221.8,47.18 221.8,48.63 221.22,49.21 212.05,49.21 210.63,47.79 210.63,46.65 208.49,44.51 188.4,44.51 183.27,49.64 182.58,49.64 180.91,51.32 180.91,55.08 171.76,64.22 171.76,73.65 173.05,74.94 173.05,75 173.08,75.04 173.08,80.2 169.65,83.63 169.65,86.57
  BOTTOM w0.254: v2(151.44,96.84) 151.76,96.52 U14.J15 ; PC88.1 163.24,126.15 167.23,126.15 PC89.1 PR127.1
  BOTTOM w0.508: v2(306.94,85) 306.94,85.18 307.22,85.46 C435.1 307.6,85.3 307.6,84.6 C438.1 C443.1 ; C443.1 307.58,80.75 307.58,80.5 310.22,77.86 311.34,77.86 ; C443.1 307.07,80.89 306.69,80.5 v2(306.69,80.38) ; v2(312.71,85.86) 312.71,85.7 312.67,85.66 C436.1 312.67,84.97 312.89,84.74 C439.1 312.93,84.15 C437.1 314.44,84.15 316.19,82.41 316.42,82.41 317.41,81.42 317.41,80.48 316.92,80 v2(316.37,80) 316.09,80 314.31,78.22
  vias: v1(154.16,118.35) v1(159.8,121.09) v1(252.61,43.9) v2(158.53,122.87) v2(159.19,122.87) v2(159.83,122.85) v2(160.46,122.85) v2(160.76,112.3) v2(161.39,112.3) v2(251.54,49.52) v2(252.41,49.52) v2(277.55,44.87) v2(277.58,44.23) v2(313.19,73.57) v2(313.75,74) v3(154.9,117.46) v3(154.9,116.72) v3(155.68,117.46) v3(155.68,116.72)
+1.05V_RUN: length 223.6
  TOP w0.457: C64.1 152.7,96.19 v2(153.35,96.84)
  TOP w0.483: PR11.2 116.39,116.83 116.9,116.32 v3(117.03,116.32)
  TOP w0.508: v3(144.33,113.91) 148.09,113.91 151.27,110.73 L2.1 ; v2(155.75,94.94) 155.42,94.61 C88.2
  IN2 w0.508: v2(214.58,123.21) 214.19,123.6 212.92,123.6 212.45,123.13 212.45,122.41 212.87,122 212.87,119.91 211.06,118.1 211.06,116.06 208.26,113.27 208.26,112.25 205.21,109.21 200.13,109.21 199.63,109.71 198.74,109.71 194.8,105.78 192.01,105.78 191.24,105.02 184.26,105.02 180.64,108.64 v3(180.64,114.3) ; v2(261.35,40.75) 260.54,40.75 256.84,44.45 256.84,45.73 254.38,48.19 v2(249,48.19)
  IN3 w0.508: v3(144.33,113.91) 130.28,113.91 128.68,112.3 126.65,112.3 125.33,113.63 125.33,113.63 124.6,114.36 124.6,114.36 124.58,114.37 121.71,114.37 121.42,114.09 120.58,114.09 119.74,114.92 118.85,114.92 117.46,116.32 v3(117.03,116.32) ; v2(249,48.19) 249,48.48 249.49,48.97 249.57,48.97 250.24,49.65 250.6,49.65 251.3,50.34 251.3,51.1 250.73,51.66 250.48,51.66 250.15,51.98 249.76,51.98 249.42,52.32 249.12,52.32 248.89,52.55 241.98,52.55 237.9,56.62 237.9,57.31 235.83,59.39 230.17,59.39 227.4,62.16 227.4,66.83 228.55,67.98 228.55,69.15 226.83,70.86 226.83,73.59 225.96,74.46 225.96,86.53 225.59,86.9 225.59,89.72 224.9,90.41 224.9,112.99 223.18,114.71 223.18,116.26 219.76,119.67 219.3,119.67 218.35,120.62 217.2,120.62 214.61,123.21 v2(214.58,123.21)
  BOTTOM w0.203: U14.AG17 150.46,86.95 v2(150.83,86.58) 151.21,86.95 U14.AG16
  BOTTOM w0.229: v2(151.63,86.59) 151.62,86.59 151.62,86.6 151.97,86.95 U14.AG14 U14.AG13
  BOTTOM w0.254: U14.AF9 155.11,87.5 155.39,87.78 U14.AE8 ; U14.P9 155.11,94 U14.N8 155.56,94.74 v2(155.75,94.94) ; v2(153.35,96.84) 153.3,96.79 153.56,96.52 U14.J11 ; v2(150.38,96.84) 150.69,96.52 U14.J17 ; U14.AE8 155.56,88.05 v2(155.76,88.25) 155.76,88.26 U14.AE9 ; U14.AE8 155.79,87.55 v2(155.79,87.31) 155.56,87.08 U14.AG8 ; v2(148.11,87.12) 148.12,87.12 148.12,87.08 148.17,87.13 147.89,87.4 U14.AF22 ; U14.H15 151.5,97.49 151.32,97.49 v2(151.29,97.52)
  BOTTOM w0.305: v2(148.08,92.27) 148.46,92.65 U14.T21 ; U14.H11 153.42,96.86 153.37,96.86 v2(153.35,96.84) ; U14.R21 148.46,93.47 v2(148.09,93.1)
  vias: v1(178.82,114.44) v2(152.25,110.83) v2(152.26,110.2) v3(168.28,117.84) v3(168.38,116.32) v3(168.46,117.13) v3(169.07,117.79) v3(169.2,117.05) v3(169.2,116.29) v3(169.93,117.26) v3(169.99,116.5) v3(179.32,115.37) v3(179.84,114.85) v3(180.04,115.85) v3(180.53,115.08) v3(180.86,115.78)
+1.05V_SUS: length 132.2
  TOP w0.457: C154.1 153.02,86.83 v2(153.27,86.57)
  TOP w0.508: C92.1 148.85,94.07 149.36,94.58 150.71,94.58 151.25,95.12 v2(151.25,95.14) C66.2 151.44,95.87 152.26,96.68 v2(152.26,96.84) ; R63.1 R67.1 110.85,86.48 111.16,86.17 ; v2(112.91,86.78) 112.56,86.78 111.95,86.17 111.16,86.17 ; v2(153.58,89.06) 153.55,89.09 153.55,89.14 153.04,89.65 C130.1 ; 111.16,86.17 111.16,85.61 v1(110.85,85.3)
  IN1 w0.508: v2(112.91,86.78) 113.11,86.57 115.27,86.57 v2(116.57,87.87) 117.84,89.14 117.84,89.93 119.95,92.04 124.48,92.04 125.19,91.32 139.73,91.32 140.27,91.86 143.19,91.86 143.85,92.52 145.22,92.52 147.66,94.96 148.86,94.96 149.42,94.4 150.51,94.4 v2(151.25,95.14) 152.02,94.37 152.02,92.07 153.04,91.05 153.04,89.76 153.58,89.23 v2(153.58,89.06)
  IN2 w0.508: 150.83,96.38 151.09,96.13 151.72,96.13 152.26,96.66 v2(152.26,96.84) ; 149.56,101.21 149.92,101.56 149.92,103.82 151.52,105.42 152.33,105.42 153.09,106.18 153.09,108.32 153.98,109.21 153.98,111.87 153.42,112.43 v2(153.42,117.26) ; v2(153.27,86.57) 153.27,88.33
  IN2 w1.016: 177.02,107.4 177.02,117.41
  IN3 w0.508: v3(173.9,118.48) 172.55,118.48 171.01,116.94 171.01,116.43 170.19,115.61 167.5,115.61 167.27,115.84 164.14,115.84 163.51,115.2 157.79,115.2 157.41,114.82 154.36,114.82 153.42,115.76 v2(153.42,117.26)
  BOTTOM w0.254: v2(153.58,89.06) 153.63,89.11 154.36,89.11 154.67,88.81 U14.AD10 ; v2(153.27,86.57) 153.18,86.57 U14.AH13 ; U14.J13 152.45,96.84 v2(152.26,96.84)
  BOTTOM w0.305: U14.AD8 U14.AD10
  BOTTOM w0.508: R346.2 R340.1 v2(116.57,87.87)
  BOTTOM w1.016: 175.78,104.94 175.73,104.89 175.73,97.29
  vias: v1(174.51,94.78) v1(178.6,120.08) v2(167.58,88.1) v2(168.21,88.11) v2(173.13,92.01) v2(173.77,91.98) v2(175.4,96.25) v2(175.42,95.63) v2(183.42,118.88) v3(173.92,120.05) v3(174.28,119.34) v3(174.66,120.05) v3(175.01,119.34) v3(175.4,120.05) v3(175.78,119.34) v3(176.16,120.05) v3(176.51,119.34) v3(177.02,106.39) v3(177.25,119.34) v3(177.63,118.48) v3(177.78,106.46) v3(177.99,119.19) v3(178.37,118.48) v3(178.72,119.19) v3(179.1,118.48) v3(179.46,119.19) v3(192.31,112.61) v3(192.31,111.87) v3(192.31,111.15) v3(193.1,112.61) v3(193.1,111.78) v3(193.1,111.06)
+1.35V_GFX: length 131.9
  TOP w0.229: VRAM2.H2 220.32,79.46 220.72,79.86 v2(220.72,80.42)
  TOP w0.254: VRAM1.R1 214.33,98.67 214.13,98.47 v2(214.13,98.46) ; v2(213.98,106.16) 214.08,106.06 214.41,106.06 214.59,105.87 VRAM1.F1 ; VRAM2.E9 214.73,76.81 v2(215.11,76.43) ; VRAM2.A8 215.49,73.62 215.1,74.01 v2(215.1,74) ; v2(221.68,106.81) 221.54,106.67 ; v2(215.92,104.68) 215.92,104.65 215.54,104.27 VRAM1.H2 ; v2(213.77,75.98) 213.81,76.02 VRAM2.D9 ; VRAM2.R1 221.49,85.19 v2(222.7,85.19) ; v2(215.11,80.41) 215.51,80.81 VRAM2.K8 ; v2(213.6,100.39) 214.03,99.96 214.4,99.96 VRAM1.N1 ; VRAM2.F1 221.57,77.62 221.6,77.58 221.65,77.58 v2(221.75,77.48) ; v2(214.26,75.52) 214.57,75.21 VRAM2.C9 ; v2(220.71,103.05) 220.68,103.03 220.67,103.03 VRAM1.K8 ; VRAM1.R9 221.32,98.67 v2(221.74,98.25) 222.33,98.84 222.33,99.68 221.9,100.11 v2(221.78,100.11) 221.62,100.27 VRAM1.N9 ; VRAM2.A1 221.1,73.62 220.73,73.98 ; VRAM2.N1 221.25,83.35 221.7,83.35 v2(222.28,82.77) ; 220.73,73.98 220.32,74.4 VRAM2.B2 ; 220.73,73.98 v2(220.73,74.03) ; VRAM2.K2 220.33,80.81 v2(220.72,80.42) ; v2(207.02,84.49) 207,84.48 R80.1 ; VRAM1.C1 214.29,108.27 v2(214,108.56)
  TOP w0.305: v2(213.55,84.7) 213.67,84.81 VRAM2.R9 ; VRAM1.K2 215.11,103.07 v2(215.09,103.07) ; VRAM1.G7 219.51,105.05 219.89,104.67 v2(219.88,104.67) ; v2(220.71,75.63) 220.32,76.02 VRAM2.D2 ; VRAM1.D2 VRAM1.C1 ; v2(220,110.58) 220,110.45 220.32,110.13 VRAM1.A8
  TOP w0.356: VRAM1.H9 221.19,104.27 v2(221.7,104.79) ; v2(213.8,83.15) 213.88,83.22 214.71,83.22 VRAM2.N9 ; v2(221.71,108.2) 221.19,108.2 VRAM1.C9 ; v2(213.47,109.69) 213.44,109.69 213.98,110.22 214.49,110.22 214.72,109.99 VRAM1.A1 214.72,109.87 215.51,109.07 VRAM1.B2 ; v2(220.71,75.63) 221.12,75.21 VRAM2.C1 ; v2(213.77,79.13) 213.86,79.21 VRAM2.H9
  TOP w0.381: v2(215.91,78.81) 216.02,78.71 VRAM2.G7
  TOP w0.457: v2(224.24,82.61) 224.24,82.84 224.6,83.2 225.1,83.2 225.46,83.55 C164.1 ; v2(224.14,111.99) C5.2
  TOP w0.508: v2(210.29,99.53) 210.35,99.48 210.35,98.72 C47.2 ; C176.2 225.58,77.13 v2(224.49,77.13) ; C98.2 224.4,93.84 v2(224.16,93.84) ; v2(211.16,87.9) 210.88,87.9 210.29,87.31 C159.2 210.02,87.39 207.93,87.39 207.45,87.87 R64.1 R68.1 ; C33.2 210.41,100.96 211.08,101.64 v2(211.08,102.04) ; v2(224.98,85.71) 225.23,85.97 C160.1 ; C173.2 225.65,78.21 225.2,77.76 v2(224.47,77.76) ; R89.2 226.75,81.27 v2(227.14,81.65) ; C162.2 210.73,84.18 210.73,84.19 211.18,84.64 v2(211.18,84.95) ; v2(224.17,94.52) 224.36,94.72 R47.2 ; C161.1 225,84.82 v2(224.75,84.57) ; v2(211.01,77.58) 210.54,77.58 C177.2 ; C157.2 v2(224.93,86.98) ; v2(185.06,73.28) 185.61,73.83 D2.2
  IN3 w0.254: v2(207.02,84.49) 207.02,84.42 206.58,83.98 204.97,83.98 204.82,84.13 204.29,84.13 203.75,83.6 v2(203.75,83.57)
  IN3 w0.508: v2(193.59,82.49) 193.4,82.31 193.4,80.5 195.41,78.5 195.41,76.77 191.92,73.28 v2(185.06,73.28)
  BOTTOM w0.102: VRAM4.H9 221.36,79.21 v2(221.6,78.98) ; C433.1 v2(224.98,85.71)
  BOTTOM w0.203: v2(220.71,103.05) 220.71,103.88 VRAM3.H2
  BOTTOM w0.229: 215.11,103.87 215.75,103.87 215.92,104.03 v2(215.92,104.68) ; 215.11,103.87 215.11,103.09 v2(215.09,103.07) ; 215.11,103.87 215.11,103.88 VRAM3.H9
  BOTTOM w0.254: v2(222.28,82.77) 222.2,82.85 222.2,82.93 221.86,83.27 221.36,83.27 221.3,83.21 VRAM2.N1 ; VRAM2.K2 220.33,80.81 v2(220.72,80.42) ; v2(219.88,104.67) 219.95,104.67 220.32,104.3 VRAM3.H2 ; VRAM4.B2 215.5,74.42 215.1,74.01 v2(215.1,74) 215.1,74 VRAM4.A1 ; VRAM3.H9 214.44,104 v2(213.65,104) ; VRAM2.C9 214.57,75.21 v2(214.26,75.52) ; VRAM1.K8 220.67,103.03 220.68,103.03 v2(220.71,103.05) ; VRAM1.N9 221.67,100.27 221.78,100.16 v2(221.78,100.11) ; v2(213.7,107.48) 213.86,107.64 214.55,107.64 VRAM3.D9 ; VRAM1.R9 221.32,98.67 v2(221.74,98.25) ; VRAM2.R9 213.64,84.81 213.55,84.72 v2(213.55,84.7) ; v2(222.7,85.19) 221.49,85.19 VRAM2.R1 ; v2(214.13,98.46) 214.13,98.47 214.33,98.67 VRAM1.R1 ; v2(213.6,100.39) 214.03,99.96 214.4,99.96 VRAM1.N1 ; VRAM1.C1 214.6,108.38 214.27,108.38 214.1,108.56 v2(214,108.56) ; v2(218.98,79.23) 218.98,78.83 219.36,78.45 219.48,78.45 VRAM4.G7 ; VRAM2.N9 213.87,83.21 v2(213.8,83.15) ; v2(203.75,83.57) 203.33,84 U13.B26 ; VRAM3.B2 220.92,109.68 VRAM3.A1 221.37,110.13 v2(221.37,110.43) ; VRAM3.F1 221.16,105.87 221.68,106.39 v2(221.68,106.81) ; v2(221.71,108.2) 221.19,108.2 VRAM1.C9 VRAM3.D2
  BOTTOM w0.305: VRAM3.E9 214.2,106.16 v2(213.98,106.16) ; v2(215.11,76.43) 215.11,76.42 VRAM4.D2 ; VRAM2.C1 221.11,75.22 v2(220.71,75.63) 221.1,76.02 VRAM4.D9 221.32,76.22 221.32,76.61 VRAM4.E9 ; v2(220.73,74.03) 220.32,73.62 VRAM4.A8 ; U13.L24 201.3,91.82 v2(201.3,91.84) ; VRAM3.G7 216.32,105.07 v2(215.92,104.68) ; v2(212.71,77.3) 212.83,77.43 214.38,77.43 214.57,77.62 VRAM4.F1 ; VRAM1.K2 215.5,102.67 v2(215.09,103.07)
  BOTTOM w0.33: v2(202.88,91.02) 202.88,91 U13.L26 ; U13.E26 203.3,86.43 v2(203.7,86.03)
  BOTTOM w0.356: v2(215.11,80.41) 215.11,80.54 215.38,80.81 VRAM2.K8 ; VRAM3.A8 215.01,110.37 214.13,110.37 213.44,109.69 v2(213.47,109.69) ; VRAM4.H2 215.73,79 v2(215.91,78.81)
  BOTTOM w0.381: U13.H26 203.83,88.94 v2(203.88,88.98) ; v2(201.28,88.54) 201.3,88.54 U13.H24 ; U13.B26 203.28,84 202.9,84.38 202.9,84.4 U13.C25 ; v2(200.45,86.05) U13.E23
  BOTTOM w0.406: v2(210.29,99.53) 210.29,99.21 210.44,99.07 C428.1 ; C427.1 210.74,102.47 211.08,102.12 v2(211.08,102.04)
  BOTTOM w0.457: R398.2 184.63,74.21 185.06,73.79 v2(185.06,73.28) ; C447.1 210.79,78.84 v2(210.98,79.03)
  BOTTOM w0.508: v2(224.09,96) 224.1,96.01 C431.2 ; v2(224.93,87.64) 225.26,87.64 225.65,87.24 C432.2 ; C429.2 224.12,97.26 v2(224.11,97.27) ; C414.1 v2(224.17,108.33) ; C434.2 210.54,84.95 v2(211.18,84.95) ; v2(223.99,101.59) 224.01,101.61 224.61,101.61 R301.2 ; v2(224.75,84.57) 224.85,84.67 225.55,84.67 R360.2 ; v2(211.44,97.19) 210.72,97.19 C430.2 ; C407.1 224.32,109.61 v2(224.06,109.36)
  vias: v1(200.41,91.15) v2(192.97,87.62) v2(193.86,87.64) v2(194.65,87.64) v2(196.25,87.72) v2(197.93,87.67) v2(198.56,96.43) v2(198.76,87.69) v2(199.22,96.43) v2(199.65,91.83) v2(199.65,91.05) v2(199.68,90.18) v2(211.06,104.51) v2(211.39,103.97) v3(227.08,78.78) v3(227.74,76.9) v3(227.74,76.16) v3(227.82,79.01) v3(227.82,78.22) v3(228.18,77.53) v3(228.63,79.01) v3(228.66,78.19) v3(228.91,77.47) v3(229.42,78.98) v3(229.4,78.19) v3(229.65,77.47)
+2VREF: length 5.5
  TOP w0.102: 132.52,32.14 132.22,32.44 132.22,33.5 132.62,33.9 133.43,33.9 v1(133.51,33.97)
  TOP w0.203: PC52.2 132.44,32.14 131.71,31.41 131.71,31.38 131.71,31.38 PU4.3
+3.3V_ALW: length 553.1
  TOP w0.254: PR24.1 v2(14.92,88.69) ; v2(53.45,28.18) 53.7,28.43 53.7,29.2 53.42,29.48 PR67.2 ; PU4.7 128.42,29.34 127.98,29.77 122.1,29.77 121.24,28.91 117.22,28.91 v1(116.62,28.31) 116.49,28.18 v2(115.68,28.18)
  TOP w0.508: 189.32,35.29 PQ10.2 188.63,35.29 187.89,34.56 187.89,29.42 188.7,28.61 188.7,24.27 189.01,23.96 193.31,23.96 194.3,22.97 R279.2 ; C220.2 295.37,45.11 v2(295.51,44.97) ; PR89.1 137.71,29.87 v2(137.8,29.96) ; v2(195.87,31.38) 195.87,37.17 194.38,38.66 PQ9.1 191.9,38.66 ; R220.1 289.68,34.18 290.23,34.73 v2(290.56,34.73) ; R1.2 156.04,125.54 156.68,126.17 v2(157.13,126.17) ; v2(14.61,103.75) 15.67,104.8 15.67,105.61 16.65,106.59 16.65,106.81 C23.1 17.68,107.85 HE1.2 ; R2.2 v2(171.99,125.97) ; v2(54.87,43.7) RT1.1 ; v2(294.77,51.41) 294.77,51.47 295.22,51.92 C211.2 ; v2(237.73,39.1) 237.73,38.9 236.13,37.3 236.13,33.96 R221.2 236.19,32.41 234.17,30.39 R254.2 ; v2(62.77,23.53) 63.2,23.1 PR426.1
  IN1 w0.508: v2(206.4,118.39) 208.27,118.39 211.39,121.5 212.07,121.5 213.06,120.51 218.3,120.51 219.25,119.56 220.49,119.56 221.65,118.4 v3(221.65,115.45) ; v2(28.48,13.85) 29.12,13.22 31,13.22 34.91,17.13 49.26,17.13 50.91,18.78 50.91,20.69 51.42,21.2 51.42,26.15 v2(53.45,28.18) ; v2(157.13,126.17) 157.36,126.4 171.56,126.4 v2(171.99,125.97)
  IN1 w1.016: 224.77,88.75 224.77,90.97 225.28,91.48 225.28,113.37 224.82,113.83 222.23,113.83 221.65,114.41 ; 248.06,48.96 248.06,51.85 247.51,52.41 244.94,52.41 243.98,53.38 243.98,54.91 239.83,59.06 237.81,59.06 237.65,59.22 229.65,59.22 227.36,61.5 227.36,67.09 226.25,68.21 222.13,68.21 220.89,69.46 220.89,71.11 223.17,73.39 223.73,73.39
  IN1 w2.54: 104.96,30.09 104.61,29.73 91.24,29.73
  IN2 w0.508: v2(51.32,43.7) 51.32,38.57 51.04,38.29 51.04,37.2 52.67,35.57 52.67,31.12 53.96,29.83 53.96,28.43 53.7,28.18 v2(53.45,28.18) 54.21,27.42 58.89,27.42 v2(62.77,23.53) ; v3(84.11,27.77) 84.08,27.8 84.08,34.35 v3(81.01,37.43) ; v2(293.81,41.72) 294.83,40.7 294.83,39.43 294.09,38.7 292.67,38.7 291.35,37.37 291.35,35.06 291.02,34.73 v2(290.56,34.73) 289.93,34.73 288.84,35.82 288.81,35.82 285.53,35.82 281.03,40.32 v2(281.03,41.06) ; v2(237.73,39.1) 237.73,40.37
  IN2 w1.016: 232.65,33.77 235.61,36.73 235.61,39.65 236.33,40.37 239,40.37 239.76,39.61 243.44,39.61 243.53,39.7 243.53,42.62 244.92,44 v2(244.92,44.51) 247.25,46.85
  IN3 w0.508: v2(206.4,118.39) 203.16,115.15 191.8,115.15 189.11,117.84 183.04,117.84 181.49,119.39 181.49,124.93 180.45,125.97 v2(171.99,125.97) ; v2(14.61,103.75) 14.37,103.5 14.37,100.16 14.92,99.61 v2(14.92,88.69) 14.92,86.93 19.46,82.39 19.46,68.06 17.2,65.8 17.2,59.07 16.24,58.1 16.24,56.25 19.44,53.05 36.41,53.05 41.97,47.48 46.98,47.48 50.77,43.7 v2(51.32,43.7) v2(54.87,43.7) 56.06,44.89 62.52,44.89 64.83,42.58 74.74,42.58 77.07,40.25 78.19,40.25 v3(81.01,37.43) ; v2(293.81,41.72) 293.81,42.89 295.51,44.59 v2(295.51,44.97) 295.46,45.02 295.46,47.23 294.09,48.6 294.09,49.54 294.78,50.23 294.78,51.4 v2(294.77,51.41)
  BOTTOM w0.508: v2(207.98,31.41) 207.91,31.48 R473.1 207.26,31.11 206.48,30.33 C513.1 206.1,30.09 205.47,30.72 U24.8 ; PR150.1 v2(206.4,118.39) ; v2(195.87,31.38) 195.87,31.57 195.86,31.58 195.86,31.92 195.55,32.24 R471.1 ; C484.2 R442.2 R447.2 244.1,43.29 244.92,44.11 v2(244.92,44.51) ; PR204.2 28.6,12.25 28.6,13.33 28.48,13.45 v2(28.48,13.85) 28.71,14.08 ESD6.5 ; v2(294.77,51.41) 294.77,51.47 294.88,51.57 ESD4.5 ; v2(295.51,44.97) ESD5.5 ; v2(212.02,35.57) 212.02,36.01 212.19,36.18 R468.2 ; v2(137.8,29.96) v2(137.8,32.07)
  BOTTOM w1.778: 279.43,44.06 279.43,44.87 276.37,47.94 275.51,47.94 275.48,47.97 256.62,47.97 256.5,48.09 252.28,48.09 251.93,47.74
  vias: v1(227.08,35.93) v2(190.23,38.26) v2(190.51,37.71) v2(190.85,38.26) v2(190.97,37.27) v2(191.32,37.83) v2(191.6,37.27) v2(212.68,35.57) v2(214.38,35.75) v2(221.9,36) v2(222.54,36) v2(227.34,35.27) v2(246.92,48.37) v2(246.92,47.74) v2(246.92,47.1) v2(247.63,47.71) v2(279.64,42.79) v2(279.64,42.15) v2(280.27,42.79) v2(280.27,42.15) v3(84.51,27.09) v3(85.3,27.09) v3(86.17,28.87) v3(86.17,28.13) v3(86.17,27.39) v3(109.03,32.94) v3(109.03,32.22) v3(109.81,32.22) v3(109.86,32.94) v3(110.63,32.94) v3(110.6,32.22) v3(111.49,32.94) v3(111.46,32.22) v3(222.41,115.48)
