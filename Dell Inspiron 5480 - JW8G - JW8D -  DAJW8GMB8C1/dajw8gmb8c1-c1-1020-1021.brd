# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CFG9: length 9.9
  TOP w0.102: v1(114.13,92.29) 114.59,91.83 114.77,91.83 115.27,91.33 115.27,91.3 R58.1 115.86,91.3 116.14,91.58 119.69,91.58 v2(120.07,91.2)
  BOTTOM w0.076: v2(120.07,91.2) 120.22,91.34 121.32,91.34 121.39,91.27 121.64,91.27 121.81,91.44 121.81,91.62 122.04,91.85 122.56,91.85 U14.V61
CFG10: length 15.1
  TOP w0.102: v1(111.31,91.86) 111.82,92.37 112.76,92.37 112.96,92.16 112.96,91.61 R57.1 113.57,91.59 113.57,92.41 113.93,92.77 114.33,92.77 114.76,92.34 115.22,91.88 122.47,91.88 v2(123.17,91.19)
  BOTTOM w0.076: v2(123.17,91.19) 123.47,91.49 U14.V60
CFG11: length 10.6
  BOTTOM w0.076: U14.U60 123.17,91.98 122.69,91.98 122.66,92.02 121.87,92.02 121.7,91.85 121.1,91.85 120.81,92.14 118.91,92.14 118.4,91.63 115.68,91.63
  BOTTOM w0.102: TP24.1 113.85,91.63 115.68,91.63
CFG12: length 7.5
  BOTTOM w0.076: U14.T63 121.5,93.08 117.94,93.08 117.86,93 115.86,93 115.82,92.96 115.68,92.96
  BOTTOM w0.102: TP20.1 114.98,92.96 115.68,92.96
CFG13: length 7
  BOTTOM w0.076: 115.68,92.23 116.27,92.82 117.94,92.82 118.02,92.9 121.01,92.9 121.15,92.77 121.87,92.77 U14.T62
  BOTTOM w0.102: TP22.1 115.68,92.23
CFG14: length 10.1
  TOP w0.102: v2(120.45,93.85) 120.13,94.17 118.92,94.17 117.72,95.36 115.77,95.36 115.65,95.49 115.15,95.49 114.77,95.87 TP5.1
  BOTTOM w0.076: v2(120.45,93.85) 120.82,93.48 122.43,93.48 U14.T61
CFG15: length 8.2
  TOP w0.102: TP6.1 115.81,92.32 122.3,92.32 122.34,92.27 122.75,92.27 v2(123.17,92.68)
  BOTTOM w0.076: v2(123.17,92.68) 123.17,92.8 U14.T60
CLK_27M_XTAL_IN: length 9.4
  BOTTOM w0.102: U13.C11 190.58,84.46 190.58,83.86 190.64,83.8 190.64,80.48 191.24,79.88 C445.2 191.24,79.61 190.58,78.95 190.58,77.48 191.46,76.61 Y2.3
CLK_27M_XTAL_OUT: length 9.3
  BOTTOM w0.102: Y2.1 189.38,77.64 189.59,77.43 190.25,77.43 190.38,77.56 190.38,79.04 190.69,79.34 190.69,79.64 190.58,79.74 C446.2 189.98,80.16 190.42,80.59 190.42,83.34 190.08,83.69 U13.B10
CLK_LPC_DEBUG_R: length 9.1
  TOP w0.102: v1(75.29,39.81) 76.35,39.81 R233.2 v2(76.43,38.86)
  BOTTOM w0.102: v2(76.43,38.86) 76.81,39.23 76.81,43.05 77.06,43.31 78.08,43.31 78.43,42.95 CN14.71
CLK_PCIE_CR_N: length 130.5
  TOP w0.102: U9.6 58.37,35.46 58.27,35.37 58.27,35.22 58.61,34.89 58.61,34.11 v2(58.78,33.94)
  IN3 w0.102: v2(135.52,103.52) 135.32,103.32 128.65,103.32 126.38,101.05 122.51,101.05 121.29,99.83 118.68,99.83 117.85,99.01 115.31,99.01 108.8,92.49 108.8,87.02 106.36,84.59 106.36,78.73 104.99,77.35 104.99,61.94 101.13,58.08 101.13,54.06 82.84,35.77 65.13,35.77 64.91,36 63.26,36 60.37,33.12 58.88,33.12 58.59,33.4 58.59,33.75 v2(58.78,33.94)
  BOTTOM w0.076: U14.B41 135.4,101.26 135.35,101.31 135.14,101.31 134.91,101.54 134.91,103.14 135.1,103.33 135.33,103.33 v2(135.52,103.52)
CLK_PCIE_CR_P: length 130.5
  TOP w0.102: U9.5 57.97,35.43 58.02,35.38 58.02,35.12 58.35,34.78 58.35,34.15 v2(58.14,33.94)
  IN3 w0.102: v2(135.52,102.89) 135.31,103.09 128.75,103.09 126.47,100.82 122.61,100.82 121.39,99.6 118.77,99.6 117.95,98.78 115.41,98.78 109.03,92.4 109.03,86.93 106.59,84.49 106.59,78.63 105.22,77.26 105.22,61.84 101.35,57.98 101.35,53.96 82.94,35.55 65.04,35.55 64.81,35.77 63.36,35.77 60.47,32.89 58.79,32.89 58.36,33.31 58.36,33.71 v2(58.14,33.94)
  BOTTOM w0.076: U14.A41 135.4,101.52 135.34,101.46 135.2,101.46 135.06,101.61 135.06,103.07 135.16,103.17 135.23,103.17 v2(135.52,102.89)
CLK_PCIE_LANN: length 218.3
  TOP w0.102: v2(280.02,46.33) 280.02,46.58 280.29,46.85 280.43,46.85 280.75,47.17 280.75,48.2 282.33,49.79 283.68,49.79 283.89,50 286.14,50 287.06,50.91 288.47,50.91 288.54,50.84 288.54,50.7 288.4,50.55 U6.16
  IN1 w0.102: v2(280.02,46.33) 279.78,46.57 279.51,46.57 278.29,45.35 277.43,45.35 276.97,44.89 274.13,44.89 273.69,45.33 272.75,45.33 272.65,45.22 271.66,45.22 271.53,45.35 262.14,45.35 260.42,43.64 260.42,43.13 259.47,42.18 256.61,42.18 256.27,41.83 254.17,41.83 253.6,41.26 240.27,41.26 239.73,40.72 232.25,40.72 231.78,41.18 222.26,41.18 221.83,40.75 220.89,40.75 220.43,40.3 217.46,40.3 217.14,39.98 209.3,39.98 209.01,40.27 201.71,40.27 201.37,40.61 200.97,40.61 195.69,45.88 195.69,52.39 192.44,55.64 192.16,55.64 183.42,64.38 183.42,65.16 181.24,67.35 181.24,68.52 180.35,69.4 180.35,77.56 179.61,78.29 179.61,80.07 180.04,80.5 180.04,82.05 180.86,82.87 180.86,84.16 180.22,84.8 180.22,86.65 179.71,87.16 179.71,90.21 179.31,90.61 179.31,91.46 177.83,92.93 177.83,93.74 176.77,94.8 176.77,96.79 176.16,97.4 176.16,98.23 174.15,100.24 170.98,100.24 170.32,100.9 164.96,100.9 162.75,103.11 160.05,103.11 157.57,105.6 147.57,105.6 147.17,105.19 146.1,105.19 145.18,104.28 142.76,104.28 141.99,103.52 141.48,103.52 141.28,103.52 141,103.24 141,102.68 140.34,102.02 140.03,102.02 139,100.99 136.51,100.99 135.97,101.52 135.97,104.19 135.85,104.32 135.66,104.32 v2(135.54,104.2)
  BOTTOM w0.076: U14.C41 135.14,100.7 135.14,100.88 134.73,101.29 134.73,103.44 134.94,103.65 134.94,104.22 135.11,104.38 135.36,104.38 v2(135.54,104.2)
CLK_PCIE_LANP: length 218.3
  TOP w0.102: U6.15 288.8,50.95 288.58,51.17 286.95,51.17 286.04,50.25 283.78,50.25 283.58,50.04 282.23,50.04 280.49,48.31 280.49,47.27 280.33,47.1 280.14,47.1 v2(280.02,47.23)
  IN1 w0.102: v2(280.02,47.23) 279.66,46.87 279.38,46.87 278.16,45.66 277.3,45.66 276.84,45.2 274.25,45.2 273.82,45.63 272.63,45.63 272.52,45.53 271.79,45.53 271.66,45.66 262.01,45.66 260.12,43.76 260.12,43.25 259.34,42.48 256.48,42.48 256.14,42.14 254.05,42.14 253.47,41.57 240.14,41.57 239.6,41.02 232.37,41.02 231.91,41.49 222.13,41.49 221.7,41.06 220.76,41.06 220.3,40.6 217.33,40.6 217.02,40.28 209.43,40.28 209.14,40.58 201.83,40.58 201.5,40.91 201.09,40.91 195.99,46.01 195.99,52.51 192.57,55.94 192.29,55.94 183.73,64.5 183.73,65.29 181.54,67.47 181.54,68.64 180.65,69.53 180.65,77.68 179.92,78.42 179.92,79.95 180.35,80.38 180.35,81.93 181.16,82.74 181.16,84.29 180.53,84.92 180.53,86.78 180.02,87.29 180.02,90.33 179.61,90.74 179.61,91.59 178.14,93.06 178.14,93.86 177.07,94.93 177.07,96.91 176.46,97.52 176.46,98.36 174.28,100.54 171.1,100.54 170.44,101.21 165.08,101.21 162.87,103.41 160.18,103.41 157.69,105.9 147.45,105.9 147.04,105.5 145.97,105.5 145.06,104.58 142.63,104.58 141.87,103.82 141.36,103.82 141.16,103.82 140.7,103.36 140.7,103.11 140.7,102.81 140.22,102.32 139.9,102.32 138.87,101.29 136.63,101.29 136.28,101.65 136.28,104.32 135.98,104.62 135.76,104.62 v2(135.54,104.84)
  BOTTOM w0.076: U14.B42 134.84,100.97 134.58,101.22 134.58,101.35 134.58,103.5 134.79,103.71 134.79,104.28 135.05,104.53 135.24,104.53 v2(135.54,104.84)
CLK_PCIE_VGAN: length 72.4
  IN3 w0.102: v2(188.03,101.79) 188.03,102.06 187.96,102.13 182.78,102.13 181.52,103.39 181.52,110.46 176.34,115.63 173.97,115.63 172.52,114.18 171.38,114.18 170.92,113.73 164.62,113.73 163.78,112.89 163.5,112.89 160.49,112.89 159.11,111.52 158.23,111.52 158.23,111.52 157.64,111.52 143.87,111.52 142.53,110.17 140.39,110.17 138.34,108.13 138.34,104.76 138.22,104.63 138.22,103.27 137.48,102.54 137.08,102.54 v2(136.79,102.25)
  BOTTOM w0.076: U14.A39 136.78,101.57 136.86,101.49 137.03,101.49 137.08,101.54 137.08,101.98 137.19,102.09 137.19,102.44 137.1,102.53 136.96,102.53 136.79,102.36 v2(136.79,102.25)
  BOTTOM w0.102: U13.AD8 188.16,102.2 188.03,102.07 v2(188.03,101.79)
CLK_PCIE_VGAP: length 72.4
  IN3 w0.102: v2(136.79,102.89) 136.91,102.77 137.39,102.77 137.99,103.37 137.99,104.73 138.12,104.85 138.12,108.22 140.29,110.4 142.43,110.4 143.78,111.75 157.59,111.75 158.28,111.75 159.02,111.75 160.39,113.12 163.59,113.12 163.59,113.12 163.69,113.12 164.52,113.96 170.82,113.96 171.28,114.41 172.42,114.41 173.87,115.86 176.44,115.86 181.75,110.55 181.75,103.49 182.88,102.36 187.78,102.36 v2(188.04,102.62)
  BOTTOM w0.076: v2(136.79,102.89) 136.99,102.68 137.17,102.68 137.35,102.5 137.35,102.02 137.24,101.91 137.24,101.48 137.1,101.34 136.86,101.34 136.78,101.26 U14.B39
  BOTTOM w0.102: v2(188.04,102.62) 188.06,102.62 U13.AE8
CLK_PCIE_WLANN: length 116.1
  IN3 w0.102: v2(77.43,37.82) 78,37.25 78.98,37.25 79.61,36.61 82.49,36.61 100.08,54.21 100.08,58.28 104.15,62.34 104.15,77.76 105.52,79.13 105.52,84.97 107.96,87.41 107.96,92.84 115.2,100.09 117.61,100.09 118.22,100.7 118.88,100.7 119.16,100.98 121.22,100.98 122.13,101.89 125.69,101.89 128.38,104.58 133.46,104.58 135.11,106.24 136.98,106.24 137.37,105.85 137.37,104.55 137.15,104.32 136.87,104.32 v2(136.7,104.15)
  BOTTOM w0.076: v2(136.7,104.15) 136.87,104.32 137.16,104.32 137.3,104.19 137.3,103.03 137.61,102.72 137.61,102.05 137.45,101.89 137.45,100.87 U14.B38
  BOTTOM w0.102: CN14.49 78.34,37.45 78.21,37.33 77.92,37.33 v2(77.43,37.82)
CLK_PCIE_WLANP: length 116.1
  IN3 w0.102: v2(136.69,104.79) 136.93,104.55 137.05,104.55 137.14,104.64 137.14,105.75 136.89,106.01 135.21,106.01 133.55,104.35 128.47,104.35 125.78,101.66 122.23,101.66 121.31,100.75 119.25,100.75 118.98,100.47 118.31,100.47 117.71,99.86 115.3,99.86 108.19,92.75 108.19,87.32 105.75,84.88 105.75,79.04 104.38,77.67 104.38,62.25 100.31,58.18 100.31,54.11 82.58,36.38 79.52,36.38 78.88,37.02 77.9,37.02 v2(77.43,36.55)
  BOTTOM w0.076: U14.C37 137.91,100.61 137.6,100.92 137.6,101.83 137.76,101.99 137.76,102.78 137.45,103.09 137.45,104.26 137.23,104.48 137,104.48 v2(136.69,104.79)
  BOTTOM w0.102: v2(77.43,36.55) 77.95,37.08 78.29,37.08 78.42,36.95 CN14.47
CLKREQ_C1: length 6
  TOP w0.102: Q9.2 181.11,74.54 Q8.3 178.6,75.2 v1(178.42,75.37) 178.43,75.38 R113.2 R104.1
CLKRUN#: length 141.3
  TOP w0.102: v2(157.69,92.07) 157.72,92.03 159.44,92.03 159.95,92.54 159.95,92.98 v1(160.35,93.37) 160.8,93.82 162.98,93.82 164.09,94.93 164.09,95.26 164.73,95.9 165.35,95.9 R43.1
  IN1 w0.089: v2(157.69,92.07) 157.86,92.24 159.52,92.24 160.18,92.9 160.18,93.53 160.49,93.84 162.54,93.84 163.23,93.15 163.58,93.15 164.27,92.47 165.36,92.47 166.15,91.68 166.15,88.57 167.43,87.3 168.25,87.3 170.65,84.9 171.71,84.9 172.97,83.64 172.97,78.14 171.23,76.4 171.23,71.62 172.72,70.14 172.72,68 174.03,66.68 174.03,65.9 175.06,64.87 175.06,64.83 185.38,54.51 185.38,50.96 186.45,49.89 186.45,46.31 186.83,45.93 186.83,45.13 192.78,39.18 193.39,39.18 196.83,35.74 196.83,33.64 197.61,32.87 200.07,32.87 200.95,33.75 203.35,33.75 206.98,30.12 208.71,30.12 209.93,28.9 220.11,28.9 220.39,29.17 220.39,29.46 220.62,29.7 222.35,29.7 222.7,30.05 230.86,30.05 231.45,30.64 v2(235.52,30.64)
  BOTTOM w0.102: U14.V5 157.51,91.89 v2(157.69,92.07) ; v2(235.52,30.64) 235.52,30.83 234.35,32 234.35,32.86 234.58,33.09 U23.93
CMPIN: length 9.7
  TOP w0.254: PU3.4 48.23,25.65 v2(48.37,25.51)
  BOTTOM w0.254: PR108.2 PR111.1 48.94,20.81 PR110.1 49.78,20.7 50.02,20.94 50.02,23.86 v2(48.37,25.51)
CMPOUT: length 16.1
  TOP w0.102: v2(51.62,20.31) 51.16,19.85 v1(51.16,19.49)
  TOP w0.254: PR428.1 51.96,20.31 v2(51.62,20.31) ; PU3.3 47.73,25.58 v2(47.72,25.56)
  BOTTOM w0.254: v2(47.72,25.56) 48.17,26.02 48.62,26.02 50.4,24.24 50.4,21.2 51.29,20.31 v2(51.62,20.31) 51.23,19.92 PR110.2 47.99,19.92 PR115.2 PR112.1
COMBOJACK: length 5.2
  TOP w0.254: R268.1 312.88,27.66 C352.2 312.12,27.44 v2(311.89,27.21)
  BOTTOM w0.254: v2(311.89,27.21) 311.72,27.21 v1(311.23,27.7) 311.23,27.82 312.28,28.87 312.28,29.04 Q48.2
CR_CLKREQ#: length 5.8
  TOP w0.102: U9.2 56.77,34.75 v1(56.4,34.38) 55.86,33.84 R230.1 55.86,33.52 55.96,33.52 56.26,33.22 56.26,32.09 56.27,32.08 56.27,31.75 55.74,31.21 R243.1
CR_RST#: length 3.5
  TOP w0.102: U9.1 55.82,35.99 55.15,35.32 55.15,34.67 55.11,34.63 v1(55.1,34.63) 54.59,34.12 R229.1
DC_TEST_A3_B3: length 0.7
  BOTTOM w0.305: U14.A3 158.88,101.62 U14.B3
DC_TEST_A61_B61: length 0.7
  BOTTOM w0.305: U14.B61 122.83,101.36 122.76,101.43 U14.A61
DC_TEST_AY2_AW2: length 0.7
  BOTTOM w0.381: U14.AY2 159.57,79.14 159.57,79.68 U14.AW2
DC_TEST_AY3_AW3: length 0.7
  BOTTOM w0.279: U14.AW3 158.88,79.72 U14.AY3
DC_TEST_AY61_AW61: length 7.5
  BOTTOM w0.102: 122.56,78.81 122.47,78.81 122.36,78.7 121.93,78.7 121.57,78.34 121.57,77.63 123.76,75.44 v1(123.76,74.03)
  BOTTOM w0.381: 122.56,78.81 122.73,78.99 U14.AY61 122.73,79.68 U14.AW61
DC_TEST_AY62_AW62: length 6.5
  BOTTOM w0.102: 121.7,79.11 121.27,78.68 121.27,75.53 v1(122.44,74.36)
  BOTTOM w0.381: U14.AW62 122.08,79.68 U14.AY62 121.7,79.11
DC_TEST_B62_B63: length 0.7
  BOTTOM w0.305: U14.B62 121.84,101.01 121.71,101.15 U14.B63
DC_TEST_C1_C2: length 0.7
  BOTTOM w0.305: U14.C2 159.56,100.54 160.09,100.54 U14.C1
DCAP: length 6.2
  TOP w0.102: PU6.16 201.66,22.63 201.82,22.79 201.82,22.9 200.48,24.24 PC73.2 199.47,24.24 198.78,24.94 197.71,24.94 v1(197.21,24.45)
DCIN_EN: length 5
  TOP w0.102: U2.13 313.71,81.66 313.8,81.57 314.12,81.57 R91.2 314.68,80.89 315.12,80.45 v1(316.97,80.45)
DDCBUF: length 4.8
  TOP w0.102: U2.14 v2(314.05,82.06)
  BOTTOM w0.102: R367.1 313.96,82.16 v2(314.05,82.06) 314.18,81.94 R370.2 315.06,80.89 v1(315.12,80.95)
DDR3_DRAMRST#: length 72.2
  TOP w0.102: v2(155.38,57.85) 155.01,58.22 R140.1 v1(155.01,59.57)
  IN3 w0.114: v2(155.38,57.85) 155.41,57.82 155.41,57.75 152.76,55.1 150.45,55.1 142.87,47.52 142.87,44.96 140.25,42.34 140.25,40.59 139.58,39.91 139.34,39.91 136.97,37.54 125.7,37.54 125.36,37.88 125.36,38.29 v2(124.95,38.7)
  BOTTOM w0.076: 150.43,71.92 151.72,73.21 151.72,78.45 151.98,78.7 151.98,79.95 151.52,80.41 U14.AV15
  BOTTOM w0.102: 150.43,71.92 150.02,71.51 150.02,64.96 155.38,59.6 v2(155.38,57.85) ; JDIM1.30 124.31,38.05 v2(124.95,38.7)
DDR_PG_CTRL: length 28.3
  TOP w0.102: PR39.1 111.36,55.36 111.49,55.23 112.38,55.23 112.49,55.12 U5.4 112.49,53.31 112.25,53.07 111.49,53.07 111.36,52.95 109.58,52.95 109.2,52.56 R151.2 R150.2 107.63,52.06 107.22,51.65 107.22,49.87 107.73,49.36 108.57,49.36 109.06,48.87 109.06,48.03 109.56,47.53 Q18.2 108.92,46.37 107.95,45.39 Q19.3 107.95,43.94 v1(108.67,43.22) 108.67,42.76 108.26,42.35 104.53,42.35 104.2,42.68 Q44.2
DDR_PWRGD: length 31.8
  TOP w0.102: v2(182.08,38.04) 182.29,37.82 182.74,37.82 182.85,37.7 R196.2
  TOP w0.152: PU5.13 170.18,28.91 170.02,29.07 170.02,30.33 168.97,31.38 v2(168.97,31.48)
  IN1 w0.089: v2(168.97,31.48) 171.03,31.48 171.15,31.36 173.57,31.36 173.77,31.15 178.04,31.15 181.01,28.18 v2(181.01,26.83)
  BOTTOM w0.102: v2(182.08,38.04) 182.05,38.01 182.05,27.01 181.87,26.83 v2(181.01,26.83)
DDR_VTTREF: length 4.6
  TOP w0.102: v1(178.82,28.43) 178.46,28.8 177.1,28.8 176.89,28.58 PC62.2
  TOP w0.152: PU5.5 176.19,28.41 176.39,28.21 PC62.2
DEVSLP1: length 186
  TOP w0.102: R275.1 283.95,25.49 284.16,25.69 284.16,26.45 283.13,27.48 283.13,30.34 282.25,31.23 281.24,31.23 v2(280.91,31.56) 280.73,31.74 v1(280.73,32.35)
  IN1 w0.089: v2(280.91,31.56) 280.91,31.15 279.87,30.11 270.01,30.11 267.98,32.14 266.6,32.14 264.48,34.26 261.31,34.26 260.82,33.77 257.54,33.77 257.18,34.13 253.22,34.13 252.43,33.34 250.02,33.34 249.54,33.81 244.06,33.81 243.44,33.2 236.46,33.2 234.48,31.22 231.21,31.22 230.72,30.72 221.93,30.72 221.48,30.27 219.33,30.27 218.65,29.59 210.2,29.59 209.07,30.72 207.27,30.72 203.56,34.43 200.4,34.43 199.56,33.6 198.01,33.6 197.4,34.21 197.4,35.98 193.62,39.76 193,39.76 187.4,45.37 187.4,46.17 187.02,46.54 187.02,50.13 186.04,51.11 186.04,54.66 175.63,65.07 175.63,65.12 174.6,66.14 174.6,66.95 173.37,68.18 173.37,70.77 173.54,70.94 173.54,85.74 172.65,86.63 171.71,86.63 169.58,88.76 169.58,92.39 167.27,94.7 162.89,94.7 162.73,94.86 161.93,95.66 v2(161.93,96)
  BOTTOM w0.076: 162.33,96.4 161.93,96.01 v2(161.93,96) 161.39,95.46 160.44,95.46 160.34,95.56 159.78,95.56 U14.L2
  BOTTOM w0.102: 162.33,96.4 163.68,97.75 R307.1
DEVSLP1_R: length 3.1
  TOP w0.102: CN17.10 283.95,23.3 R275.2 283.93,24.33 v1(282.93,24.33)
DEVSLP2: length 19.4
  TOP w0.102: v2(157.68,94.92) 157.79,95.03 158.74,95.03 159.08,95.37 159.5,95.37 v1(159.77,95.64) 159.77,95.72 160.51,96.46 161.49,96.46 162.12,97.08 162.76,97.08 164.74,99.07 169.96,99.07 170.16,98.87 171.13,98.87 172.02,99.76 173.66,99.76 R34.1
  BOTTOM w0.102: v2(157.68,94.92) 157.51,94.75 U14.N5
DGPU_EDIDCLK: length 4.1
  BOTTOM w0.102: U13.A9 189.28,81.94 187.82,80.48 R373.2
DGPU_EDIDDATA: length 5.7
  BOTTOM w0.102: R374.2 186.8,80.33 188.1,81.62 188.67,81.62 189.01,81.96 189.01,82.87 188.87,83 188.87,83.28 189.28,83.69 U13.B9
DGPU_HOLD_RST#: length 28.6
  TOP w0.102: R50.1 180.89,95.32 180.75,95.46 179.33,95.46 179.1,95.24 179.1,94.5 178.8,94.19 177.55,94.19 177.2,94.55 177.2,94.73 176.93,95 U1.1 176.43,95.86 175.45,96.84 v1(173.77,96.84) 173.19,97.42 170.49,97.42 169.45,98.46 165.33,98.46 162.01,95.14 162.01,94.96 161.69,94.63 158.98,94.63 v2(158.49,94.14)
  BOTTOM w0.076: U14.P3 158.84,93.79 v2(158.49,94.14)
DGPU_OVT#: length 32.1
  TOP w0.102: R157.1 v1(187.48,49.04) 190.03,51.6 191.68,51.6 v2(193.71,53.63)
  BOTTOM w0.102: v2(193.71,53.63) 193.71,54.49 191.75,56.45 191.75,60.11 187.82,64.04 187.82,66.05 187.05,66.81 186.72,66.81 185.89,67.65 185.89,71.26 186.52,71.89 Q39.3
DGPU_PGOK-1: length 13.7
  BOTTOM w0.102: Q35.3 179.51,77.28 178.95,76.72 Q36.2 179.46,75.7 179.54,75.62 179.54,74.43 179.26,74.15 R399.1 C461.1 178.93,72.45 180.99,70.39 183.85,70.39 v1(184.34,69.91)
DGPU_POK2: length 4.4
  BOTTOM w0.102: C462.1 184.35,72.08 v1(184.13,72.3) 184.13,72.78 184.39,73.04 R398.1 183.59,74.43 Q38.2
DGPU_POK4: length 6.8
  BOTTOM w0.102: v1(186.75,75.22) 186.16,74.64 185.24,74.64 R386.1 C448.1 184.51,77.31 184.16,77.66 183.6,77.66 183.32,77.94 Q35.2
DGPU_PR_EN_G: length 248.4
  TOP w0.102: v2(192.69,56.93) 192.25,56.49 181.81,56.49 180.25,58.05 169.63,58.05 161.63,50.05 121.55,50.05 120.46,48.96 120.46,41.17 118.42,39.14 118.42,38.21 116.85,36.64 114.18,36.64 113.85,36.31 94.79,36.31 94.52,36.04 94.52,31.94 94.14,31.56 94.14,27.52 94.5,27.16 v1(94.65,27.16) 94.78,27.16 95.18,26.76 95.18,25.07 PR101.1 PR100.2 93.09,24.73 PQ18.3
  IN2 w0.114: v2(223.99,118.96) 225.36,117.59 225.36,90.36 225.63,90.09 225.63,80.19 225.18,79.74 224.29,79.74 223.66,79.11 223.66,72.76 221.37,70.47 210.78,70.47 201.79,79.46 198.98,79.46 198.25,78.74 193.93,74.41 192.72,74.41 191.95,73.65 190.74,73.65 189.87,72.78 189.87,72.06 189.19,71.38 189.19,68.49 189.31,68.37 189.31,65.92 188.17,64.78 188.17,61.61 189.34,60.44 192.41,60.44 193.07,59.78 193.07,57.31 v2(192.69,56.93)
  BOTTOM w0.102: v2(223.99,118.96) 223.6,118.58 223.6,117.74 PQ29.2 ; PQ37.2 197.11,56.53 196.83,56.25 196.83,55.36 196.45,54.98 195.33,54.98 195.03,55.28 195.03,56.04 194.17,56.91 192.72,56.91 v2(192.69,56.93)
DGPU_PSI: length 109
  TOP w0.102: PR60.2 234.39,46.64 v2(233.88,47.15)
  IN2 w0.114: v2(189.87,69.89) 189.87,69.99 189.74,70.12 189.74,71.28 190.33,71.87 190.33,72.59 190.93,73.19 192.14,73.19 192.91,73.96 194.12,73.96 199.02,78.85 199.03,78.85 199.06,78.88 201.73,78.88 210.62,69.99 221.47,69.99 223.02,68.44 226.68,68.44 227.42,67.7 227.42,62.3 230.35,59.37 239.39,59.37 243.34,55.42 243.34,51.34 240.5,48.5 238.92,48.5 237.04,46.62 235.47,46.62 234.93,47.15 v2(233.88,47.15)
  IN3 w0.114: v2(189.87,69.89) 189.83,69.94 185.53,69.94 185.07,70.39 185.07,72.49 184.63,72.93 184.63,73.46 185.2,74.03 185.91,74.03 186.55,74.66 186.55,81.32 185.19,82.68 v2(184.94,82.68)
  BOTTOM w0.102: U13.B4 184.76,83.66 184.76,82.86 v2(184.94,82.68)
DGPU_PWM_VID: length 101.3
  TOP w0.254: v2(190.05,63.13) 189.97,63.05 189.97,62.32 191.32,60.97 193.28,60.97 194.32,59.93 194.32,59.5 198.33,55.49 198.33,46.88 200.83,44.39 220.58,44.39 v1(221.03,44.83) 222.11,45.91 230.97,45.91 232.27,44.61 235.19,44.61 236.99,46.42 236.99,47.36 236.62,47.73 PR55.2
  IN3 w0.254: v2(187.18,86.85) 186.52,86.19 185.78,86.19 185.05,85.46 184.81,85.46 182.25,82.9 182.25,76.43 181.85,76.02 181.85,70.71 182.25,70.31 182.25,68.89 179.87,66.51 179.87,65.66 182.44,63.08 190,63.08 v2(190.05,63.13)
  BOTTOM w0.102: U13.E7 187.6,86.44 v2(187.18,86.85)
DGPU_PWR_EN: length 327
  TOP w0.102: v2(161.3,95.97) 161.3,95.97 162.14,96.81 162.77,96.81 164.83,98.87 169.76,98.87 169.96,98.67 171.32,98.67 171.57,98.92 R36.1 ; PR105.1 88.78,25.52 PD4.1 89.01,24.32 89.39,23.94 92.41,23.94 92.95,23.4 94.72,23.4 94.93,23.61 94.93,24.27 95.46,24.8 95.46,27.29 94.78,27.98 v1(94.78,30.75) 94.78,35.72 95.08,36.03 114.08,36.03 114.49,36.44 116.95,36.44 118.63,38.11 118.63,39.05 120.66,41.08 120.66,48.73 121.78,49.85 162.06,49.85 169.42,57.2 v2(173.14,57.2) 173.54,57.59 179.79,57.59 181.16,56.22 192.36,56.22 192.43,56.29 v2(193.28,56.29) ; PR54.1 232.34,46.8 v2(232.78,47.24)
  IN2 w0.114: v2(193.28,56.29) 193.68,56.69 193.68,59.65 192.67,60.67 189.43,60.67 188.4,61.7 188.4,64.17 189.64,65.42 189.64,68.21 190.46,69.02 190.46,70.01 189.97,70.5 189.97,71.15 190.56,71.74 190.56,72.5 191.02,72.96 192.24,72.96 192.97,73.7 194.2,73.7 199.15,78.65 201.63,78.65 210.52,69.76 221.29,69.76 222.84,68.21 226.59,68.21 227.14,67.67 227.14,67.48 227.14,67.48 227.14,62.24 230.34,59.04 239.07,59.04 243.09,55.03 243.09,51.41 240.4,48.73 237.65,48.73 236.63,47.71 233.23,47.71 232.76,47.24 v2(232.78,47.24)
  IN3 w0.114: v2(173.14,57.2) 174.49,58.54 174.49,69.72 175.07,70.31 179.19,70.31 180.02,71.13 180.02,76.92 179.35,77.6 179.35,81.21 178.99,81.56 178.99,86.86 179.22,87.09 179.22,87.11 179.65,87.54 179.65,92.21 179.22,92.64 179.22,94.83 171.5,102.55 165.9,102.55 162.88,99.53 162.27,99.53 161.1,99.53 160.26,98.69 160.26,97.21 161.3,96.18 v2(161.3,95.97)
  BOTTOM w0.076: U14.L3 159.34,95.72 160.41,95.72 160.51,95.62 161.15,95.62 161.3,95.77 v2(161.3,95.97)
DGPU_PWROK: length 27.6
  TOP w0.102: v1(176.44,77.58) 176.82,77.2 v2(176.82,76.81) 176.91,76.72 177.52,76.72 177.65,76.59 R113.1
  BOTTOM w0.102: v2(176.82,76.81) 177.19,76.44 177.68,76.44 178.29,77.05 Q36.3 178.29,79.1 R377.2 R371.1 177.73,79.57 177.73,79.13 177.58,78.98 175.62,78.98 175.42,79.18 175.42,82 175.01,82.41 175.01,83.43 175.78,84.19 175.78,87.97 175.62,88.12 175.62,91.58 173.87,93.33 D8.1
DGPU_VC_EN: length 46
  TOP w0.102: PD1.2 249.92,48.88 249.92,46.75 v2(249.94,46.72) ; v2(253.98,46.82) 257.27,46.82 PR190.2 258.88,47.03 260.03,47.03 260.31,47.31 261.48,47.31 262.16,47.99 PD7.1
  TOP w0.254: PR36.2 233.3,56.4 v2(233.79,55.92) 233.9,55.81 PU1.16
  IN1 w0.089: v2(249.94,46.72) 249.71,46.49 246.09,46.49 245.35,47.23 245.35,47.91 243.06,50.2 243.06,54.9 239.56,58.41 234.73,58.41 233.79,57.47 v2(233.79,55.92)
  BOTTOM w0.102: v2(249.94,46.72) 250.15,46.72 v1(250.6,46.26) 250.88,46.54 252.84,46.54 253.12,46.82 v2(253.98,46.82)
DIGITAL_CLK: length 360.2
  TOP w0.102: L6.1 C31.2 15.36,101.37 v2(15.02,101.71) ; R195.1 299.41,37.45 R194.1 C276.1 297.6,38.01 296.83,38.01 295.77,39.08 294.92,39.08 294.7,38.86 292.93,38.86 291.95,37.88 290.56,37.88 290.01,37.34 v2(290.01,36.73)
  IN1 w0.089: v2(83.15,39.2) 83.15,39.12 83.57,38.7 104.88,38.7 106.1,39.91 109.56,39.91 111.59,37.88 114.28,37.88 116.39,35.77 138.82,35.77 140.48,34.11 145.03,34.11 146.46,32.68 154.31,32.68 156.68,35.04 180.83,35.04 186.77,29.09 186.77,27.7 188.17,26.3 190.43,26.3 192.9,23.84 199.04,23.84 200.27,22.61 201.39,22.61 201.58,22.8 203.54,22.8 205,21.35 209.86,21.35 210.19,21.02 211.9,21.02 212.25,21.37 222.31,21.37 222.98,22.05 228.92,22.05 230.01,20.95 233.76,20.95 234.36,21.54 237.8,21.54 240.92,24.67 243.13,24.67 243.37,24.91 244.75,26.29 251.88,26.29 252.79,25.38 261.28,25.38 261.37,25.47 264.98,25.47 266.8,23.66 282.74,23.66 284.46,25.39 284.46,26.7 285.33,27.57 285.33,32.52 286.09,33.28 287.23,33.28 288.25,34.29 288.25,34.94 290.04,36.73 v2(290.01,36.73)
  IN3 w0.114: v2(15.02,101.71) 15.57,101.16 15.57,87.52 24.32,78.77 24.32,67.61 42.18,49.74 47.53,49.74 49.51,47.76 81.67,47.76 83.15,46.29 v2(83.15,39.2)
DIGITAL_CLK2_R: length 13.8
  TOP w0.102: R26.1 18.63,103.49 v2(18.5,103.62) ; v2(22.03,101.15) 22,101.15 21.47,100.62 20.3,100.62 19.91,101.01 C32.2 L6.2
  BOTTOM w0.102: CN1.11 24.03,101.45 23.9,101.32 23.3,101.32 22.72,100.74 22.15,100.74 22.03,100.86 v2(22.03,101.15) 21.49,100.62 21,100.62 20.38,101.24 20.38,101.81 20.38,101.81 20.38,101.97 20.38,101.98 20.38,102.25 19.58,103.05 19.07,103.05 v2(18.5,103.62)
DIGITAL_CLK_R: length 5.7
  TOP w0.102: R26.2 21.24,103.03 21.85,103.03 v2(22.03,103.21) 22.84,103.21 v1(23.35,102.7)
  BOTTOM w0.102: CN1.8 22.29,102.95 v2(22.03,103.21)
DIGITAL_D1: length 357.6
  TOP w0.102: R214.1 299.39,35.47 C314.1 297.65,35.06 296.03,35.06 R215.1 295.83,35.12 295.52,34.82 294.56,34.82 294.34,35.04 291.85,35.04 291.3,35.6 290.93,35.6 v2(290.69,35.36) ; L7.1 C34.2 15.36,100.05 v2(14.99,100.42)
  IN1 w0.089: v2(82.53,39.1) 83.02,38.62 83.29,38.62 83.62,38.29 105.32,38.29 106.64,39.61 109.23,39.61 111.39,37.45 114.38,37.45 116.37,35.47 138.67,35.47 140.29,33.84 144.81,33.84 146.21,32.45 154.44,32.45 156.8,34.81 180.65,34.81 186.5,28.97 186.5,27.47 187.87,26.1 190.23,26.1 192.74,23.58 198.89,23.58 200.05,22.42 201.47,22.42 201.66,22.61 203.47,22.61 204.92,21.16 209.3,21.16 209.77,20.69 212.12,20.69 212.56,21.12 222.99,21.12 223.71,21.83 228.86,21.83 229.93,20.76 233.94,20.76 234.48,21.3 237.85,21.3 241.04,24.48 243.26,24.48 244.78,26 251.85,26 252.66,25.19 261.36,25.19 261.45,25.28 264.9,25.28 266.73,23.46 285.53,23.46 286.55,24.47 286.55,26.78 286.13,27.19 286.13,31.97 286.64,32.48 287.56,32.48 290.21,35.12 290.45,35.12 v2(290.69,35.36)
  IN3 w0.114: v2(82.53,39.1) 82.53,46.21 81.29,47.46 49.31,47.46 47.35,49.41 42.19,49.41 24.09,67.51 24.09,78.5 15.34,87.24 15.34,99.87 14.99,100.22 v2(14.99,100.42)
DIGITAL_D1_R: length 4.1
  TOP w0.102: R29.2 21.24,102.81 21.73,102.81 v2(22.03,102.5)
  BOTTOM w0.102: CN1.9 22.08,102.45 v2(22.03,102.5)
DIGITAL_D2_R: length 13.8
  TOP w0.102: L7.2 C35.2 19.91,99.88 20.28,100.24 21.67,100.24 v2(21.98,99.94) ; R29.1 v2(18.5,102.35)
  BOTTOM w0.102: CN1.12 23.98,100.95 23.82,101.12 23.39,101.12 22.81,100.54 22.08,100.54 21.98,100.44 v2(21.98,99.94) 21.5,100.42 20.92,100.42 20.18,101.15 20.18,101.32 20.18,101.32 20.18,102.16 19.49,102.85 19,102.85 v2(18.5,102.35)
DIMM1_SA0: length 3.2
  TOP w0.102: R164.1 176.77,46.17 v2(176.81,46.21) 176.41,46.21 v1(176.13,46.49)
  BOTTOM w0.102: JDIM1.197 v2(176.81,46.21)
DIMM1_SA1: length 6
  TOP w0.102: v1(180.09,46.47) 179.81,46.19 179.38,46.19 178.8,45.6 178.8,45.1 178.13,44.43 R165.1 177.68,44.07 v2(177.68,43.37)
  BOTTOM w0.102: v2(177.68,43.37) 177.91,43.6 177.91,43.78 178.01,43.88 JDIM1.201
DMIC_CLK_R: length 9
  TOP w0.102: U10.2 302.28,36.78 301.96,37.09 301.96,37.43 301.4,37.98 300.73,37.98 R195.2 299.79,37.05 298.96,37.05 298.94,37.07 298.43,37.07 298.31,36.94 296.86,36.94 v1(295.41,38.39)
DMIC_D1_R: length 9.6
  TOP w0.102: v1(294.04,36.79) 295.74,36.79 295.89,36.64 298.09,36.64 298.68,36.04 299.97,36.04 300.2,35.81 300.2,35.44 R214.2 300.27,35.37 301.02,35.37 301.2,35.55 301.93,35.55 302.11,35.73 302.3,35.73 302.35,35.78 U10.4
DP_ENVDD: length 192.5
  TOP w0.102: v2(263,36.87) 263.51,36.87 v1(263.8,36.57) 264.52,35.85 264.52,35.62 265.2,34.95 R235.1
  IN1 w0.089: v2(172.04,104.74) 172.38,105.07 173.74,105.07 178.37,100.44 179.68,100.44 180.5,99.63 180.5,97.73 183.87,94.36 183.87,91.24 185.42,89.69 185.42,86.61 185.84,86.19 185.84,84.24 186.35,83.72 186.35,80.77 184.35,78.77 184.2,78.77 183.83,78.41 183.83,77.37 184.13,77.08 184.13,73.16 185.01,72.29 185.01,69.67 186.25,68.43 186.25,67.71 187.78,66.18 187.78,65.45 189.11,64.12 189.65,64.12 190.55,63.22 190.55,63.08 190.55,62.69 192.12,61.11 192.78,61.11 193.16,60.73 193.16,60.73 198.21,55.68 199.51,54.38 199.51,47.18 202.31,44.38 219.56,44.38 220.72,45.54 237.95,45.54 238.22,45.81 248.8,45.81 v2(249.08,45.53)
  BOTTOM w0.076: 158.93,102.5 158.86,102.42 158.33,102.42 158.05,102.7 157.39,102.7 157.03,102.35 157.03,101.56 156.59,101.12 156.59,100.76 U14.C6
  BOTTOM w0.102: v2(263,36.87) 263,38.06 266.31,41.38 270.38,41.38 270.94,41.93 270.94,42.85 271.43,43.34 273.31,43.34 273.78,43.81 274.16,43.81 D18.1 274.35,45.27 274.23,45.4 274.23,46.16 273.57,46.82 255.05,46.82 254.41,46.19 251.7,46.19 250.99,45.48 250.68,45.48 250.2,45.96 249.51,45.96 v2(249.08,45.53) ; 158.93,102.5 159.14,102.7 160.9,102.7 162.17,103.97 162.2,103.97 162.23,104 162.33,104 162.92,104.59 162.92,105.12 163.53,105.73 164.19,105.73 165.24,104.68 171.99,104.68 v2(172.04,104.74)
DP_UTIL: length 6.9
  BOTTOM w0.076: v1(133.71,106.97) 134.27,106.41 134.27,105.62 R291.1 R290.1 134.81,104.96 134.27,104.43 U14.A43
DPWROK: length 103.8
  IN3 w0.114: v2(232.11,37.5) 231.71,37.1 229.75,37.1 228.79,38.05 221.49,38.05 220.73,37.3 215.58,37.3 215.2,37.68 213.32,37.68 213.06,37.43 210.76,37.43 210.45,37.73 201.76,37.73 201.35,38.14 199.07,38.14 192.9,44.31 191.11,44.31 189.05,46.37 189.05,49.45 189.59,50 190.13,50 v2(190.25,50.13)
  BOTTOM w0.102: U23.106 230.29,31.16 230.46,31.33 231.28,31.33 231.53,31.58 231.53,31.96 230.48,33.01 230.48,35.54 232.11,37.17 v2(232.11,37.5) ; v2(190.25,50.13) 190.31,50.18 190.31,50.81 190.23,50.89 190.23,52.3 188.63,53.9 188.63,57.37 179.91,66.09 179.91,67.21 178.22,68.9 164.72,68.9 162.8,70.82 R403.2
DPWROK_R: length 11.4
  BOTTOM w0.076: U14.AV5 157.48,80.14 157.22,79.88 157.22,78.85 157.44,78.63 157.44,77.92 158.41,76.95 161.17,76.95 161.6,76.52 R390.1 161.61,75.7 162.07,75.7 162.16,75.61 162.16,75.12 162.32,74.96 R389.1 162.75,74.23
  BOTTOM w0.102: R403.1 162.75,73.58 162.75,74.23
DSP_GPIO: length 44.6
  TOP w0.102: U10.46 304.56,38.95 304,39.51 299.93,39.51 299.55,39.89 298.04,39.89 297.18,40.75 296.67,40.75 R528.1 295.62,40.75 292.92,40.75 291.35,39.18 287.99,39.18 v1(286.77,37.96) 286.47,37.65 284.01,37.65 283.31,36.96 283.31,36.58 282.02,35.29 281.45,35.29 280.54,36.21 278.9,36.21 278.11,36.99 272.65,36.99 271.59,38.06 271.59,39.13 272.22,39.76 272.22,40.78 272.78,41.34 272.78,42.07 272.36,42.5 U7.27
DSP_I2C_CK: length 13
  TOP w0.102: U7.6 265.49,41.7 265.39,41.79 263.75,41.79 R171.2 263.52,42.45 263.3,42.66 261.98,42.66 v2(261.35,42.02) 261.23,42.15 261.23,43.3 Q20.1 ; v2(257.28,41.52) 257.78,42.01 R466.1
  IN3 w0.114: v2(261.35,42.02) 260.84,41.52 v2(257.28,41.52)
DSP_I2C_DA: length 13.7
  TOP w0.102: U7.5 264.59,42.1 R173.2 R484.1 264.27,44.18 v2(264.52,44.44) ; Q20.4 259.05,45.21 259.32,44.94 259.32,43.55 v2(259.44,43.42)
  BOTTOM w0.102: v2(259.44,43.42) 260.26,44.23 v1(260.69,44.23) 261.4,44.94 264.02,44.94 v2(264.52,44.44)
DSP_PLTRST#: length 25.4
  TOP w0.102: v2(271.2,44.21) 271.2,44.33 271.04,44.5 U7.31
  BOTTOM w0.102: v2(271.2,44.21) 270.92,43.93 268.59,43.93 267.19,42.53 266.81,42.53 265.17,40.89 264.39,40.89 262.74,42.53 260.54,42.53 260.38,42.68 258.96,42.68 258,43.65 252.56,43.65 251.7,42.79 v1(251.7,41.64) R450.1
DSP_RST#: length 21.8
  TOP w0.102: R28.1 173.7,103.5 171.56,103.5 v1(169.62,101.57) 169.26,101.21 164.4,101.21 162.57,99.38 160.69,99.38 160.03,98.71 160.03,98.28 159.76,98 158.71,98 157.89,97.19 157.89,96.71 157.06,95.88 v2(157.03,95.88)
  BOTTOM w0.102: U14.L6 156.86,95.7 v2(157.03,95.88)
DSWVRMEN: length 8.7
  BOTTOM w0.076: U14.AW7 156.31,79.47 156.31,77.72 156.57,77.46 156.75,77.46
  BOTTOM w0.102: R406.1 159.65,73.55 159.65,76.03 159.34,76.34 157.87,76.34 156.75,77.46
EARP_L: length 5.7
  TOP w0.102: v1(316.8,36.77) 316.55,36.52 316.55,35.36 316.4,35.22 315.44,35.22 L14.1
  TOP w0.254: R217.1 313.52,34.91 314.41,35.8 L14.1
EARP_L1: length 8.4
  TOP w0.254: L14.2 315.7,35.87 C284.1 316.36,37.19 316.75,37.58 316.75,38.49 316.92,38.66 C270.1 318.52,37.6 v1(318.78,37.6) 319.24,37.6 320.3,36.54 CN12.1
EARP_L2: length 4.8
  TOP w0.102: R217.2 312.3,34.91 312.81,34.4 313.85,34.4 v1(314.26,34.81)
  TOP w0.254: U10.31 310.71,34.78 310.75,34.73 311.56,34.73 311.74,34.91 R217.2
EARP_R: length 7.5
  TOP w0.254: v2(313.67,36.05) 313.55,35.93 R210.1 ; L15.1 315.96,33.23 316.47,33.74 316.47,34.45 316.09,34.83 315.17,34.83 v2(314.94,34.61)
  IN3 w0.254: v2(313.67,36.05) 314.94,34.78 v2(314.94,34.61)
  BOTTOM w0.102: v2(313.67,36.05) v1(313.67,34.81)
EARP_R1: length 16
  TOP w0.254: L15.2 315.96,30.6 C337.1 C341.1 316.45,29.58 316.59,29.72 v2(316.59,29.91)
  IN1 w0.254: CN12.2 324.29,26.64 317.45,26.64 316.39,27.7 316.39,29.7 v2(316.59,29.91)
  BOTTOM w0.102: v2(316.59,29.91) v1(315.98,30.52)
EARP_R2: length 5.9
  TOP w0.102: R210.2 312.27,36.2 312.53,36.46 314.28,36.46 v1(314.69,36.87)
  TOP w0.254: U10.32 310.77,35.28 310.96,35.09 311.41,35.09 311.74,35.41 311.74,35.72 311.95,35.93 R210.2
EC_CS_EXT: length 128.7
  TOP w0.102: v2(210.96,41.54) 210.96,41.31 211.36,40.91 212.96,40.91 v1(213.27,40.6) 214,39.86 R182.2
  IN3 w0.114: v2(210.96,41.54) 210.8,41.39 203.74,41.39 203.31,41.82 200.13,41.82 192.29,49.67 192.29,51.05 191.72,51.62 191.71,51.62 191.38,51.95 180.12,51.95 178.94,50.77 176.52,50.77 173.27,54.02 173.27,56.35 176.5,59.57 176.5,67.5 175.12,68.89 175.12,69.68 175.38,69.94 179.28,69.94 180.25,70.9 180.25,77.21 179.62,77.85 179.62,81.05 180.16,81.59 180.16,82.21 179.4,82.97 179.4,84.68 179.22,84.86 179.22,86.68 179.98,87.44 179.98,92.78 180.11,92.92 180.11,93.97 179.68,94.4 179.68,94.9 171.29,103.29 165.6,103.29 162.57,100.27 159.29,100.27 157.77,98.74 157.77,95.92 v2(157.72,95.87)
  BOTTOM w0.102: U14.L5 157.51,95.66 v2(157.72,95.87)
EC_DSP_RST#: length 17.7
  TOP w0.102: v2(240.44,38.24) 240.93,38.72 243.06,38.72 243.26,38.52 246.21,38.52 246.79,37.93 v2(246.79,37.88)
  BOTTOM w0.102: v2(240.44,38.24) 240.44,38.4 239.94,38.9 v1(238.87,38.9) 238.25,38.9 238.04,38.69 U23.79 ; v2(246.79,37.88) 246.79,37.93 248.35,39.49 248.35,40.92 249.08,41.64 R450.2
EC_PWROK: length 185.8
  TOP w0.102: R128.2 111.23,70.72 110.73,70.22 110.73,68.95 112.12,67.55 112.12,63.23 113.04,62.32 114.44,62.32 115.56,61.2 117.58,61.2 118.6,60.18 v1(118.6,59.04) 118.6,58.16 122.83,53.94 157.76,53.94 161.81,57.98 161.81,64.04 v2(164.07,66.31)
  IN3 w0.114: v2(191.07,49.39) 190.79,49.11 190.78,49.11 189.77,48.1 189.77,46.67 191.4,45.05 193.18,45.05 199.36,38.87 201.64,38.87 202.06,38.45 210.99,38.45 211.55,39.01 217.19,39.01 217.84,38.37 219.53,38.37 219.72,38.55 226.79,38.55 227.56,39.32 235.91,39.32 v2(237.52,37.71)
  BOTTOM w0.102: U23.82 237.3,37.49 v2(237.52,37.71) ; R391.1 159.27,74.88 159.27,72.02 158.25,71 158.25,68.21 160.1,66.36 164.02,66.36 v2(164.07,66.31) 165.08,67.32 171.32,67.32 171.88,67.88 177.88,67.88 178.94,66.81 178.94,65.69 187.49,57.14 187.49,53.67 189.26,51.9 189.26,49.51 189.72,49.05 190.1,49.05 190.43,49.39 v2(191.07,49.39)
EC_PWROK_R: length 7.8
  BOTTOM w0.076: R391.2 158.99,75.93 158.83,76.08 157.82,76.08 156.7,77.2 156.45,77.2 156.02,77.63 U14.AY7
  BOTTOM w0.102: R391.2 158.86,75.69 158.76,75.58 v1(158.76,73.85)
EC_RTC_RST: length 104.6
  TOP w0.102: v2(170.62,67.73) 171,67.73 171.64,68.36 176,68.36 176.54,68.9 176.54,69.07 176.46,69.15 v1(176.46,69.23) 176.46,69.61 175.78,70.29 174.3,70.29 173.71,69.7 R519.1 172.07,69.7 171.96,69.81 Q47.2 ; v2(227.04,43.78) 227.04,43.76 225.62,42.34 225.62,42.28 212.61,42.28 211.9,41.57 v2(211.9,41.54)
  IN2 w0.114: v2(170.62,67.73) 170.82,67.52 170.82,63.97 180.16,54.63 180.16,51.08 182.53,48.7 183.14,48.7 188.02,43.83 209.94,43.83 211.9,41.87 v2(211.9,41.54)
  BOTTOM w0.102: U23.119 225.09,31.07 225.28,31.25 225.28,33.69 224.52,34.45 224.52,35.39 224.72,35.6 224.72,36.21 225.08,36.56 228.28,36.56 228.71,36.99 228.71,37.63 227.67,38.67 227.67,39.08 228.2,39.61 228.2,42.58 227.04,43.74 v2(227.04,43.78)
EC_SPI_CLK: length 63.1
  TOP w0.102: v2(192.82,37.48) 193.19,37.48 193.96,36.71 193.96,36.13 194.47,35.62 194.47,30.89 194.9,30.47 195.76,30.47 196.32,29.9 196.32,27.88 197.67,26.53 v2(197.67,26.33)
  IN3 w0.114: v2(197.67,26.33) 198.4,25.6 202.86,25.6 204.68,23.79 206.38,23.79 206.38,23.79 206.79,23.79 207.1,23.79 207.97,23.79 208.67,23.09 220.19,23.09 220.51,22.77 224.43,22.77 225.08,23.42 230.84,23.42 231.59,24.18 231.59,24.43 231.99,24.83 232.75,24.83 v2(233.18,24.4)
  BOTTOM w0.102: v2(192.82,37.48) 191.72,38.57 191.12,38.57 190.71,38.98 v1(190.23,38.98) 189.97,39.23 R457.1 ; U23.97 233.89,29.22 234.32,28.79 234.32,27.72 234.48,27.57 234.48,26.68 233.67,25.87 233.67,24.88 v2(233.18,24.4)
EC_SPI_CS0#: length 50.5
  TOP w0.102: v2(205.98,25.03) 205.98,28.36 206.46,28.84 206.46,29.37 205.52,30.31 205.52,31.56 205.33,31.74 v1(205.33,35.47) R204.1
  IN3 w0.114: v2(235.8,27.19) 235.44,26.83 235.09,26.83 233.52,25.27 230.92,25.27 230.03,24.38 230.03,24.38 229.81,24.16 220.78,24.16 220.44,23.82 208.98,23.82 208.28,24.52 207.4,24.52 207.4,24.52 206.49,24.52 206.48,24.52 v2(205.98,25.03)
  BOTTOM w0.102: U23.96 236.38,31.89 236.51,31.76 236.51,30.36 237.17,29.7 237.17,28.26 236.66,27.75 236.36,27.75 v2(235.8,27.19)
EC_SPI_CS#: length 46.2
  IN3 w0.114: v2(233.36,27.65) 233.79,27.21 233.79,26.4 233.03,25.64 230.77,25.64 229.66,24.53 220.51,24.53 220.2,24.22 209.1,24.22 208.43,24.89 207.82,24.89 207.07,25.64 204.35,25.64 203.64,26.35 199.69,26.35 199.37,26.67 198.86,27.18 198.65,27.18 v2(197.52,28.31)
  BOTTOM w0.102: v2(233.36,27.65) 233.36,28.69 232.88,29.17 232.44,29.17 232.29,29.32 U23.101 ; U24.1 v1(197,29.32) 197,29.11 197.52,28.59 v2(197.52,28.31)
EC_SPI_DIN: length 49.6
  IN3 w0.114: v2(208.42,25.56) 209.39,24.59 219.86,24.59 220.17,24.9 229.5,24.9 230.63,26.02 231.63,26.02 231.73,26.12 231.73,26.94 231.63,27.04 230.69,27.04 230.59,27.14 230.59,27.39 230.69,27.49 232.16,27.49 232.27,27.6 232.27,27.82 232.16,27.93 231.28,27.93 231.17,28.03 231.17,28.31 231.28,28.41 232.55,28.41 232.65,28.31 232.65,27.11 232.75,27.01 v2(233.15,27.01)
  BOTTOM w0.102: U24.5 205.72,34.53 v1(206.36,33.9) 206.59,33.9 209.29,31.19 209.29,29.08 208.82,28.61 208.82,25.97 v2(208.42,25.56) ; v2(233.15,27.01) 232.93,27.24 232.93,28.75 232.71,28.97 232.16,28.97 231.89,29.24 U23.102
EC_SPI_DO: length 51.3
  IN3 w0.114: v2(196.88,28.31) 196.88,28.03 198.1,26.81 198.71,26.81 199.22,26.3 199.55,25.97 202.71,25.97 202.71,25.97 203.01,25.97 204.83,24.15 206.23,24.15 206.64,24.15 207.25,24.15 207.25,24.15 208.13,24.15 208.82,23.46 220.68,23.46 220.96,23.18 224.32,23.18 224.93,23.79 230.55,23.79 v2(231.12,24.37)
  BOTTOM w0.102: U23.103 231.49,29.33 232.06,28.76 232.62,28.76 232.73,28.66 232.73,26.44 231.12,24.83 v2(231.12,24.37) ; v2(196.88,28.31) 196.88,27.98 197.21,27.65 197.72,27.65 198.2,28.13 v1(198.2,28.82) 198.2,31.66 197.87,31.99 U24.2
EC_SPI_SI: length 59.9
  TOP w0.102: v2(193.56,36.54) 193.61,36.49 193.61,35.9 194.12,35.39 194.12,30.75 194.75,30.11 195.49,30.11 195.97,29.64 195.97,27.72 196.99,26.71 v2(196.99,26.33)
  IN3 w0.114: v2(232.14,24.37) 232.14,24.2 231.06,23.13 225.31,23.13 224.57,22.39 223.05,22.39 222.8,22.14 212.88,22.14 212.3,22.72 208.52,22.72 207.82,23.42 206.94,23.42 204.52,23.42 202.77,25.17 198.14,25.17 v2(196.99,26.33)
  BOTTOM w0.102: R463.1 192.14,38.62 192.51,38.26 192.63,38.26 193.59,37.3 193.59,36.57 v2(193.56,36.54) ; U23.99 233.09,29.31 233.76,28.64 233.76,26.97 232.14,25.35 v2(232.14,24.37)
EC_SPI_SLK: length 45.4
  IN3 w0.114: v2(207.81,26.28) 208.06,26.02 208.8,26.02 209.55,25.27 227.31,25.27 227.41,25.37 227.41,25.82 227.52,25.92 227.74,25.92 227.85,25.82 227.85,25.37 227.95,25.27 228.28,25.27 228.38,25.37 228.38,25.69 228.48,25.79 228.81,25.79 228.91,25.69 228.91,25.37 229.01,25.27 229.35,25.27 229.75,25.67 229.75,27.34 229.65,27.44 228.86,27.44 228.76,27.34 228.76,26.94 228.66,26.83 228.38,26.83 228.28,26.94 228.28,27.34 228.18,27.44 227.67,27.44 227.57,27.55 227.57,27.8 227.67,27.9 230.26,27.9 230.36,28 230.36,28.23 230.92,28.79 v2(230.92,29.02)
  BOTTOM w0.102: v2(230.92,29.02) 230.69,29.24 U23.105 ; U24.6 205.37,33.26 206,32.63 v1(206.99,32.63) 207.35,32.63 208.67,31.3 208.67,30.49 207.86,29.68 207.86,27.01 207.81,26.96 v2(207.81,26.28)
EC_SPI_SO: length 2.9
  TOP w0.102: R192.2 206.99,37.71 207.25,37.96 v1(207.25,38.21) 207.25,38.39 207.07,38.57 206.27,38.57 R186.1
EC_SPI_SO_R: length 50.3
  TOP w0.102: v2(208.97,22.21) 207.83,22.21 205.42,24.62 205.42,28.31 205.62,28.51 205.62,29.6 205.11,30.11 205.11,31.36 204.83,31.64 v1(204.83,33.56) 204.83,37.21 R192.1
  IN3 w0.114: v2(208.97,22.21) 209.08,22.31 211.97,22.31 212.56,21.73 223.17,21.73 223.43,21.98 226.74,21.98 227.31,22.55 231.21,22.55 v2(231.43,22.77)
  BOTTOM w0.102: v2(231.43,22.77) 232.72,24.07 232.72,25.43 234.12,26.83 234.12,28.66 233.49,29.29 U23.98
EC_WAKE#: length 104.2
  TOP w0.102: R134.2 166.99,71.23 169.15,73.39 169.15,73.89 169.87,74.61 172.68,74.61 173.29,74 173.29,72.6 174.68,71.21 175.78,71.21 v1(176.46,70.52) 177.43,69.56 180.48,69.56 181.21,68.82 181.75,68.82 182.41,69.48 183.04,69.48 183.24,69.68 183.24,69.69 183.3,69.74 183.3,70.14 183.24,70.19 183.24,73.34 v2(183.62,73.72)
  IN1 w0.089: v2(237.58,44.43) 236.97,45.03 220.88,45.03 219.75,43.9 202.12,43.9 199.04,46.98 199.04,54.19 192.59,60.64 191.93,60.64 187.15,65.42 186.97,65.42 186.53,65.86 186.53,66.76 185.78,67.51 185.78,68.23 184.54,69.48 184.54,72.09 183.62,73.01 v2(183.62,73.72)
  BOTTOM w0.102: v2(237.58,44.43) 237.58,43.53 236.66,42.61 236.66,42.38 236.57,42.29 U23.70
EDP_AUXN: length 262.8
  TOP w0.114: v2(263.85,32.31) 263.85,32.44 263.52,32.77 262.57,32.77 262.44,32.64 262.44,32.35 C320.2
  BOTTOM w0.076: U14.A45 132.72,101.74 132.65,101.66 132.65,101.48 132.72,101.41 133.06,101.41 133.14,101.48 133.14,101.6 133.18,101.64 133.18,102.41 133,102.59 133,103.26 132.95,103.31
  BOTTOM w0.114: v2(263.85,32.31) 263.5,32.31 263.37,32.44 263.37,32.63 263.5,32.75 264.32,32.75 264.5,32.57 264.5,32.02 263.38,30.9 259.08,30.9 254.59,26.4 246.19,26.4 244.48,24.7 241.81,24.7 239.33,22.21 237.95,20.84 237.06,19.95 234.68,17.56 201.61,17.56 197.93,21.25 196.99,21.25 195.82,22.41 195.82,23.2 193.35,25.67 193.35,29.5 191.48,31.38 187.77,31.38 187.16,31.98 v1(187.16,32.71) 186.44,32.71 183.94,35.21 183.94,40.68 182.69,41.93 182.69,45.05 181.47,46.26 181.47,48.09 180.86,48.7 178.97,48.7 178.59,48.32 176.36,48.32 175.34,49.34 145.12,49.34 133.33,61.12 122.51,61.12 113.67,69.96 111.64,69.96 105.24,76.36 105.24,88.53 105.94,89.23 105.94,93.72 106.66,94.44 106.66,99.36 112.14,104.84 116.03,104.84 116.24,104.84 119.44,108.03 129.3,108.03 132.95,104.38 132.95,103.31
EDP_AUXN_C: length 5.3
  TOP w0.114: C320.1 261.3,32.71 261.21,32.71 v1(260.69,32.19) 260.18,32.7 260.06,32.7 259.9,32.55 259.9,31.68 259.46,31.24 258.89,31.24 258.77,31.11 U25.29
EDP_AUXN_R: length 12.5
  TOP w0.114: v2(266.48,30.02) 266.21,30.29 265.35,30.29 C542.1
  BOTTOM w0.114: v2(266.48,30.02) 266.75,30.29 267.65,30.29 267.83,30.11 273.72,30.11 274.88,31.27 274.88,31.89 275,32.01 CN11.8
EDP_AUXN_RC: length 6.7
  TOP w0.114: C542.2 263.99,30.17 263.88,30.29 261.59,30.29 R505.2 260.63,30.24 258.89,30.24 258.77,30.11 U25.27
EDP_AUXP: length 262.8
  TOP w0.114: C309.2 262.92,33.02 263.63,33.02 v2(263.85,33.24)
  BOTTOM w0.076: 133.21,103.31 133.21,103.31 133.16,103.26 133.16,102.65 133.33,102.48 133.33,101.58 133.29,101.53 133.29,101.42 133.12,101.26 133.03,101.26 132.89,101.12 U14.B45
  BOTTOM w0.114: 133.21,103.31 133.21,104.49 129.41,108.29 119.33,108.29 116.14,105.09 112.03,105.09 106.41,99.47 106.41,94.55 105.69,93.83 105.69,89.33 104.99,88.64 104.99,76.26 111.54,69.71 113.57,69.71 122.41,60.87 133.23,60.87 145.01,49.08 175.24,49.08 176.26,48.07 178.69,48.07 179.08,48.45 180.75,48.45 181.21,47.99 181.21,46.16 182.43,44.94 182.43,41.83 183.68,40.57 183.68,35.11 186.27,32.52 v1(186.27,31.81) 186.98,31.81 187.66,31.13 191.37,31.13 193.1,29.4 193.1,25.56 195.56,23.1 195.56,22.31 196.88,20.99 197.82,20.99 201.51,17.31 234.78,17.31 238.82,21.35 239.16,21.69 241.92,24.45 244.59,24.45 246.29,26.15 254.69,26.15 259.19,30.64 263.48,30.64 264.75,31.91 264.75,32.68 264.42,33.01 264.09,33.01 v2(263.85,33.24)
EDP_AUXP_C: length 5.3
  TOP w0.114: U25.30 258.77,31.61 258.89,31.49 259.35,31.49 259.65,31.79 259.65,32.65 259.95,32.96 260.18,32.96 v1(260.69,33.46) 261.18,32.97 261.3,32.97 C309.1
EDP_AUXP_R: length 12.4
  TOP w0.114: v2(266.48,31) 266.48,30.82 266.21,30.54 265.35,30.54 C541.1
  BOTTOM w0.114: v2(266.48,31) 266.48,30.82 266.75,30.54 267.75,30.54 267.93,30.36 273.61,30.36 274.62,31.37 274.62,31.91 274.5,32.04 CN11.7
EDP_AUXP_RC: length 6.8
  TOP w0.114: C541.2 263.99,30.69 263.85,30.54 261.59,30.54 R506.2 260.53,30.49 258.89,30.49 258.77,30.61 U25.28
EDP_BL_EN: length 240.7
  IN1 w0.089: v2(172.11,106.36) 172.75,105.72 173.57,105.72 178.37,100.93 179.87,100.93 180.97,99.82 180.97,98.11 182.01,97.06 182.81,97.06 184.34,95.54 184.34,91.44 185.9,89.87 185.9,86.79 186.82,85.87 186.82,80.32 185.4,78.91 185.4,78.12 184.6,77.32 184.6,74.3 185.53,73.37 185.53,69.82 186.73,68.62 186.73,67.9 187.58,67.04 187.98,66.65 188.25,66.37 188.25,65.65 189.25,64.64 189.79,64.64 191.02,63.41 191.02,62.88 192.32,61.58 192.98,61.58 193.03,61.53 198.68,55.88 200.01,54.55 200.01,47.34 202.5,44.85 219.36,44.85 220.49,45.97 237.72,45.97 238.03,46.28 243.72,46.28 v2(244.71,47.28) ; v2(224.69,29.02) 225.13,28.59 231.07,28.59 232.12,29.63 234.32,29.63 234.77,29.18 238.76,29.18 241.45,31.86 v2(242.48,31.86) 244.08,31.86 245.18,30.76 252.41,30.76 252.84,30.34 257.97,30.34 258.66,31.02 264.09,31.02 264.27,31.2 265.92,31.2 266.12,31.41 267.44,31.41 269.35,29.5 280.09,29.5 280.13,29.54 280.15,29.54 281.94,31.33 281.94,31.34 282.13,31.53 282.13,33.77 v2(282.38,34.02)
  BOTTOM w0.076: 158.15,104.3 157.64,103.8 157.35,103.8 156.28,102.73 154.75,102.73 154.54,102.53 154.54,101.94 154.69,101.79 U14.A9
  BOTTOM w0.102: 158.15,104.3 158.3,104.46 160.71,104.46 161.37,105.12 161.37,106.67 161.22,106.82 161.22,108.37 161.68,108.83 162.67,108.83 163.08,108.42 163.08,107.81 163.23,107.66 163.23,107.1 165.39,104.94 169.86,104.94 171,106.08 171.84,106.08 v2(172.11,106.36) ; v2(282.38,34.02) 281.11,35.29 280.25,35.29 278.49,37.04 278.34,37.04 277.78,37.6 277.78,38.19 278.47,38.87 D22.1 ; U23.120 v2(224.69,29.02) ; v2(242.48,31.86) 243.37,32.75 244.43,32.75 245.12,33.44 245.12,37.92 247.44,40.24 247.44,44.17 v1(245.85,45.76) 244.71,46.9 v2(244.71,47.28)
EDP_COMP: length 10.1
  TOP w0.114: R22.1 148.58,107.72 148.91,108.06 148.91,108.65 v1(148.74,108.82)
  TOP w0.508: v2(149.13,100.46) 149.13,100.97 150.06,101.89 150.06,104.2 148.58,105.67 R22.1
  BOTTOM w0.254: v2(149.13,100.46) U14.D20
EDP_HP_R: length 12.4
  TOP w0.102: v2(157.54,102.3) 158.38,103.14 v1(158.38,108.27) 158.38,108.92 R17.1 R16.1
  BOTTOM w0.076: U14.D6 156.96,99.95 157.25,100.25 157.49,100.25 157.66,100.42 157.66,100.68 157.31,101.03 157.31,101.55 157.26,101.6 157.26,102.07 157.49,102.3 v2(157.54,102.3)
EDP_HPD: length 187.6
  TOP w0.102: v2(245.88,34.61) 244.58,34.61 244.36,34.38 244.36,30.81 R517.2
  TOP w0.127: v2(162.16,109.56) 162.16,109.61 161.04,110.73 R16.2
  IN1 w0.127: v2(270.72,31.48) 270.72,31.28 270.44,31 269.78,31 268.26,32.52 266.73,32.52 264.61,34.65 261.09,34.65 260.59,34.15 258.05,34.15 257.6,34.61 v2(245.88,34.61) 244.34,34.61 243.29,33.56 236.31,33.56 234.66,31.91 232.07,31.91 231.55,32.42 227.59,32.42 227.29,32.73 222.49,32.73 221.97,33.25 210.32,33.25 208.58,34.99 199.76,34.99 199.76,34.99 199.24,34.99 193.76,40.47 193.07,40.47 187.95,45.6 187.95,46.4 187.61,46.74 187.61,50.28 187.57,50.32 187.57,50.36 186.7,51.23 v2(186.7,51.5)
  IN2 w0.127: v2(162.16,109.56) 162.39,109.33 162.39,108.43 161.36,107.4 161.36,105.82 163.56,103.62 169.88,103.62 177.39,96.11 177.39,92.81 178.65,91.55 178.65,88.8 176.72,86.87 176.72,78.06 177.68,77.1 177.68,75.45 178.01,75.12 178.01,73.32 179.5,71.82 179.5,69.57 179.5,69.57 179.5,68.96 179.97,68.49 179.97,60.97 186.37,54.57 186.37,51.83 v2(186.7,51.5)
  BOTTOM w0.102: CN11.5 273.5,31.21 273.19,30.9 271.31,30.9 v2(270.72,31.48)
EDP_TXN0: length 260.5
  TOP w0.114: v2(257.16,39.53) 257.23,39.46 257.23,38.93 C282.2
  BOTTOM w0.076: 132.42,102.2 132.37,102.14 132.37,101.52 132.55,101.34 132.55,100.96 132.89,100.61 U14.C45
  BOTTOM w0.114: v2(257.16,39.53) 257.39,39.77 257.39,40.18 257.74,40.52 258.81,40.52 259.49,39.84 259.49,37.65 256.62,34.78 254.62,34.78 252.59,32.75 252.59,28.84 250.66,26.91 245.88,26.91 244.18,25.21 241.49,25.21 234.37,18.1 201.81,18.1 198.05,21.86 197.18,21.86 196.58,22.46 196.58,23.3 193.94,25.94 193.94,29.75 191.8,31.89 188.9,31.89 186.26,34.53 v1(185.58,34.53) 185.58,35.21 184.43,36.36 184.43,40.89 183.24,42.07 183.24,45.22 182,46.46 182,48.3 181.1,49.2 176.39,49.2 175.7,49.9 145.32,49.9 133.54,61.68 122.77,61.68 113.95,70.5 111.84,70.5 105.8,76.54 105.8,88.33 106.43,88.97 106.43,93.52 107.16,94.24 107.16,99.16 112.33,104.33 116.49,104.33 119.7,107.54 128.88,107.54 132.42,104 132.42,102.2
EDP_TXN0_C: length 3.1
  TOP w0.114: C282.1 257.41,37.57 257.41,36.92 256.62,36.12 256.62,35.9 256.5,35.77 U25.39
EDP_TXN0_R: length 6.4
  TOP w0.114: C528.2 260.83,28 260.33,28 v1(259.95,27.62) 259.39,28.18 259.3,28.18 258.35,27.23 256.88,27.23 256.62,27.49 256.62,27.71 256.5,27.84 U25.22
EDP_TXN0_RC: length 18.9
  TOP w0.114: C528.1 262.25,28.13 263.17,28.13 v2(263.39,27.91)
  IN3 w0.102: v2(263.39,27.91) 263.69,28.21 270.28,28.21 274.02,24.47 275.15,24.47 275.36,24.69 275.36,25.5 275.46,25.6 v2(275.9,25.6)
  BOTTOM w0.114: EL14.3 275.85,26.76 275.57,26.49 275.57,25.92 v2(275.9,25.6)
EDP_TXN0_RL: length 4.5
  BOTTOM w0.114: 275.85,30.31 275.6,30.57 275.6,30.75 276.38,31.52 276.38,31.75 276.5,31.88 CN11.11 ; 275.85,30.31 275.65,30.11 275.65,30.11 275.5,29.96 275.5,29.83 275.85,29.49 EL14.4 ; 275.85,30.31 v1(276.06,30.31)
EDP_TXN1: length 250.2
  TOP w0.114: v2(254.43,39.56) 254.44,39.56 254.54,39.45 254.54,39.01 C280.2
  BOTTOM w0.076: 130.69,104.63 131.62,103.7 131.62,101.88 U14.A47
  BOTTOM w0.114: v2(254.43,39.56) 254.68,39.81 254.68,39.95 255.05,40.32 256.14,40.32 256.6,39.86 256.6,39.31 251.65,34.35 251.65,29.15 250.17,27.67 245.45,27.67 243.87,26.1 241.16,26.1 233.91,18.85 203.75,18.85 202.11,20.48 201.22,20.48 198.83,22.87 198.02,22.87 197.42,23.48 197.42,24.44 195.54,26.32 195.54,27.21 v1(195.01,27.73) 195.54,28.26 195.54,29.42 192.31,32.65 190.07,32.65 185.18,37.54 185.18,41.2 184.13,42.24 184.13,45.42 182.79,46.77 182.79,48.57 181.41,49.95 176.89,49.95 176.19,50.65 145.91,50.65 134.09,62.47 124.5,62.47 121.96,65.01 120.68,65.01 114.36,71.33 112.7,71.33 106.56,77.48 106.56,87.9 107.2,88.53 107.2,93.22 107.91,93.93 107.91,98.85 112.63,103.57 116.87,103.57 120.07,106.77 128.55,106.77 130.69,104.63
EDP_TXN1_C: length 3
  TOP w0.114: C280.1 254.67,37.59 254.67,36.53 255.12,36.08 255.12,35.9 254.99,35.77 U25.42
EDP_TXN1_R: length 6.5
  TOP w0.114: C530.2 258.55,25.89 256.68,25.89 v1(256.27,25.49) 255.74,26.02 255.53,26.02 255.12,26.43 255.12,27.71 254.99,27.84 U25.19
EDP_TXN1_RC: length 23.6
  TOP w0.114: C530.1 260.09,25.89 260.84,25.89 261.07,26.12 266.6,26.12 v2(266.86,25.86)
  IN3 w0.102: v2(266.86,25.86) 267.15,26.15 270.94,26.15 273.36,23.74 277.28,23.74 277.9,24.36 277.9,25.5 278,25.6 v2(278.44,25.6)
  BOTTOM w0.114: v2(278.44,25.6) 278.06,25.97 278.06,26.35 278.26,26.55 EL13.3
