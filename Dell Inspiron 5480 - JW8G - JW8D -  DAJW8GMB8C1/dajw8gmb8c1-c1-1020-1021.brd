# Allegro board dajw8gmb8c1-c1-1020-1021.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ62: length 59.3
  IN1 w0.076: v2(149.9,81.83) 149.9,81.36 153.69,77.57 153.69,77.22 153.75,77.17
  IN1 w0.089: 153.75,77.17 154.86,76.05 154.86,71.2 172.68,53.38 172.68,52.46 172.82,52.32 173.27,52.32 173.41,52.19 173.41,51.91 173.27,51.77 172.82,51.77 172.68,51.63 172.68,51.35 172.82,51.21 173.16,51.21 173.29,51.08 173.29,50.78 173.16,50.65 172.82,50.65 172.68,50.51 172.68,44.59 172.94,44.33 172.94,41.67 172.6,41.34 172.6,40.66 172.73,40.52 172.92,40.52 173.05,40.66 173.05,41 v2(173.46,41.41)
  BOTTOM w0.102: v2(173.46,41.41) 175.61,43.56 JDIM1.193
  BOTTOM w0.165: U14.AR18 150.29,82.15 149.98,81.83 v2(149.9,81.83)
M_B_DQ63: length 59.8
  IN1 w0.089: v2(149.9,82.55) 150.3,82.15 150.3,81.24 153.96,77.58 153.96,77.44 155.2,76.2 155.2,71.34 173.79,52.75 173.79,50.41 173.66,50.28 173.15,50.28 173.02,50.15 173.02,49.83 173.16,49.69 173.63,49.69 173.77,49.55 173.77,49.27 173.63,49.13 173.16,49.13 173.02,48.99 173.02,48.71 173.16,48.57 173.63,48.57 173.77,48.43 173.77,48.15 173.63,48.01 173.16,48.01 173.02,47.87 173.02,47.59 173.16,47.45 173.63,47.45 173.77,47.31 173.77,47.03 173.63,46.89 173.16,46.89 173.02,46.75 173.02,45.89 173.16,45.75 173.6,45.75 173.74,45.61 173.74,45.33 173.6,45.19 173.16,45.19 173.02,45.05 173.02,44.73 173.4,44.35 173.4,43.89 174.09,43.2 174.09,42.7 173.87,42.48 173.67,42.48 v2(173.46,42.68)
  BOTTOM w0.102: v2(173.46,42.68) 173.97,42.68 175.01,43.72 JDIM1.191
  BOTTOM w0.165: U14.AP18 150.23,82.87 v2(149.9,82.55)
M_B_DQSN0: length 57
  IN3 w0.102: v2(119.52,39.36) 119.24,39.08 119.16,39.08 119.01,39.23 119.01,40.24 119.16,40.39 119.16,46.62 121.14,48.6 121.14,56.7 132.49,68.06 132.49,71.35 134.1,72.96 134.1,73.4 135.44,74.74 136.31,74.74 137.15,75.58 137.37,75.58 v2(137.73,75.22)
  BOTTOM w0.076: U14.AW30 141.87,80.26 141.8,80.26 141.75,80.15 141.75,80.02 141.82,79.86 141.82,79.66 141.8,79.61 141.76,79.52 141.75,79.5 141.75,79.37 141.76,79.35 141.83,79.2 141.83,78.91 141.69,78.76 141.69,78.36 141.05,77.72 140.22,77.72 139.32,76.83 139,76.83 138.51,76.34 138.51,76.01 v2(137.73,75.22)
  BOTTOM w0.114: JDIM1.10 118.31,37.73 118.48,37.9 118.48,38.63 118.9,39.05 119.26,39.05 119.52,39.31 v2(119.52,39.36)
M_B_DQSN1: length 54.4
  IN3 w0.102: v2(141.13,74.59) 141.34,74.38 141.64,74.38 141.84,74.18 141.84,73.29 141.18,72.63 141.18,68.69 125.77,53.28 125.77,46.04 124.57,44.84 124.57,41.28 124.35,41.06 124.19,41.06 123.96,40.83 v2(123.96,40.65)
  BOTTOM w0.076: U14.AV26 144.47,80.5 144.09,80.12 144.09,79.69 144.02,79.54 144.02,79.33 144.04,79.28 144.04,79.28 144.09,79.18 144.09,78.89 143.71,78.51 143.71,77.9 141.74,75.93 141.74,75.2 v2(141.13,74.59)
  BOTTOM w0.114: JDIM1.27 123.41,43.69 123.58,43.52 123.58,43.22 123.05,42.69 123.05,41.59 123.58,41.06 123.78,41.06 123.96,40.88 v2(123.96,40.65)
M_B_DQSN2: length 58.1
  IN3 w0.076: 146.14,77.38 146.11,77.41 146.11,78.22 142.77,81.56 142.77,82.12 142.95,82.3 142.95,83.36 143.02,83.44 143.1,83.44 v2(143.34,83.2)
  IN3 w0.102: 146.14,77.38 146.14,74.05 146.62,73.58 146.62,66.28 143.98,63.64 143.98,61.9 134.41,52.33 134.41,51.94 134.09,51.62 133.7,51.62 133.5,51.43 133.5,51.29 133.89,50.9 133.89,50.58 133.49,50.18 133.17,50.18 132.78,50.57 132.64,50.57 132.47,50.4 132.47,49.92 132.7,49.69 132.7,49.34 132.47,49.11 132.47,48.86 132.57,48.76 132.68,48.76 132.9,48.54 132.9,47.96 132.68,47.74 132.57,47.74 132.47,47.64 132.47,45.18 131.02,43.73 131.02,42.12 130.75,41.85 130.44,41.85 130.31,41.72 v2(130.31,41.41)
  BOTTOM w0.114: U14.AN28 143.67,83.52 v2(143.34,83.2) ; v2(130.31,41.41) 130.31,41.69 130.16,41.85 129.87,41.85 129.47,42.25 129.47,42.5 128.99,42.98 128.99,43.5 128.81,43.68 JDIM1.45
M_B_DQSN3: length 60.5
  IN3 w0.076: v2(145.25,83.2) 145.49,83.44 145.56,83.44 145.64,83.36 145.64,82.87 146.15,82.36 146.15,81.63 147.03,80.75 149.37,80.75 150.17,79.94 150.17,79.92 150.2,79.9 150.2,79.86 150.21,79.85
  IN3 w0.102: 150.21,79.85 151.52,78.54 151.52,72.78 151.04,72.3 151.04,64.07 148.42,61.45 148.42,57.36 137.35,46.29 137.35,41.46 135.9,40.02 135.9,39.79 135.36,39.25 135.21,39.25 135.11,39.36 v2(135.11,39.94)
  BOTTOM w0.114: JDIM1.62 133.91,37.82 134.09,38.01 134.09,38.95 134.55,39.41 134.83,39.41 135.11,39.69 v2(135.11,39.94) ; v2(145.25,83.2) 145.57,83.52 U14.AN25
M_B_DQSN4: length 53.8
  IN1 w0.076: 142.91,72.27 142.87,72.31 142.87,72.43 143.08,72.64 143.61,72.64 144.41,73.44 144.41,74.45 144.56,74.61 144.71,74.61 144.94,74.38 v2(144.94,74.31)
  IN1 w0.102: 142.91,72.27 142.91,65.29 146.96,61.24 146.96,60.5 157.95,49.52 157.95,46.01 158.11,45.85 158.11,45.13 157.95,44.97 157.95,41.96 158.19,41.72 158.35,41.72 158.49,41.85 v2(158.49,42.27)
  BOTTOM w0.076: U14.AW22 147.28,80.19 147.28,80.33 147.2,80.4 147.08,80.4 146.93,80.26 146.88,80.15 146.88,80.02 146.96,79.86 146.96,79.66 146.93,79.61 146.89,79.52 146.88,79.5 146.88,79.37 146.91,79.31 146.94,79.25 146.96,79.21 146.96,78.92 146.22,78.19 146.22,75.99 145.33,75.1 145.33,74.55 145.09,74.31 v2(144.94,74.31)
  BOTTOM w0.114: v2(158.49,42.27) 158.49,41.92 158.68,41.72 158.96,41.72 159.16,41.92 159.16,42.25 158.38,43.04 158.38,43.52 158.21,43.69 JDIM1.135
M_B_DQSN5: length 53.2
  IN1 w0.076: 146.92,72.5 146.92,72.51 146.96,72.55 146.96,72.9 147.72,73.66 147.72,74.8 v2(148.17,75.25)
  IN1 w0.102: 146.92,72.5 146.92,66.93 163.18,50.67 163.18,46.2 163.57,45.81 163.57,45.5 163.18,45.11 163.18,44.6 163.61,44.17 163.61,40.17 163.81,39.97 163.81,39.53 v2(163.3,39.03)
  BOTTOM w0.076: v2(148.17,75.25) 148.6,75.68 148.6,76.55 148.87,76.81 148.87,78.53 149.22,78.89 149.22,79.18 149.18,79.28 149.17,79.28 149.15,79.33 149.15,79.54 149.22,79.69 149.22,79.94 149.31,80.02 149.31,80.2 149.61,80.5 U14.AV18
  BOTTOM w0.114: v2(163.3,39.03) 163.74,38.59 163.74,38.44 163.51,38.21 163.51,37.91 163.31,37.71 JDIM1.152
M_B_DQSN6: length 58.3
  IN1 w0.076: v2(148,83.2) 148,83.12 147.22,82.35 146.91,82.35 146.62,82.05 146.62,81.42 148.65,79.39 149.24,79.39 150.9,77.73 150.9,75.77 150.98,75.69 150.98,75.68
  IN1 w0.102: v2(168.28,41.24) 168.28,41.51 168.48,41.71 168.74,41.71 169.01,41.98 169.01,42.92 168.68,43.25 168.68,45.41 167.8,46.29 167.8,52.06 151.11,68.74 151.11,72.66 150.98,72.79 150.98,75.68
  BOTTOM w0.114: U14.AN21 148.39,83.34 148.24,83.2 v2(148,83.2) ; JDIM1.169 168.41,43.8 168.59,43.62 168.59,43.53 168.3,43.24 167.87,43.24 167.52,42.89 167.52,41.99 167.8,41.72 168.12,41.72 168.28,41.55 v2(168.28,41.24)
M_B_DQSN7: length 60.9
  IN1 w0.076: v2(149.9,83.2) 149.9,83.32 150.06,83.48 150.24,83.48 150.48,83.24 150.48,81.31 151.65,80.14 152.24,80.14 154.31,78.07 154.31,78.04 154.47,77.89
  IN1 w0.102: v2(173.19,39.94) 173.57,39.94 173.76,40.13 173.76,40.74 174.14,41.13 174.14,41.44 174.72,42.02 174.72,43.5 174.03,44.19 174.03,44.72 174.42,45.11 174.42,53.03 157.28,70.17 157.28,70.52 157.5,70.74 157.5,70.88 157.21,71.17 157.07,71.17 156.84,70.95 156.5,70.95 155.85,71.6 155.85,76.5 154.47,77.89
  BOTTOM w0.114: v2(149.9,83.2) 150.17,83.2 150.29,83.32 U14.AN18 ; JDIM1.186 173.51,37.72 173.69,37.91 173.69,39.43 v2(173.19,39.94)
M_B_DQSP0: length 56.9
  IN3 w0.102: v2(119.52,38.72) 119.36,38.87 119.08,38.87 118.8,39.14 118.8,40.32 118.96,40.47 118.96,46.7 120.94,48.69 120.94,56.79 132.29,68.14 132.29,71.44 133.9,73.05 133.9,73.48 135.36,74.94 136.23,74.94 137.07,75.78 137.65,75.78 v2(137.73,75.86)
  BOTTOM w0.076: v2(137.73,75.86) 137.81,75.78 138.05,75.78 138.35,76.08 138.35,76.41 138.93,76.99 139.25,76.99 140.15,77.89 140.98,77.89 141.52,78.43 141.52,78.83 141.66,78.98 141.66,79.16 141.61,79.28 141.61,79.28 141.59,79.33 141.59,79.54 141.66,79.69 141.66,79.83 141.61,79.93 141.59,79.98 141.59,80.19 141.66,80.35 141.72,80.41 141.81,80.5 141.81,80.51 U14.AV30
  BOTTOM w0.114: JDIM1.12 118.91,37.73 118.74,37.9 118.74,38.53 119.01,38.8 119.44,38.8 v2(119.52,38.72)
M_B_DQSP1: length 54.2
  IN3 w0.102: v2(123.96,41.92) 123.96,41.36 124.06,41.26 124.27,41.26 124.37,41.36 124.37,44.93 125.57,46.13 125.57,53.37 140.98,68.78 140.98,72.71 141.64,73.37 141.64,74.1 141.55,74.18 141.26,74.18 141.13,74.05 v2(141.13,73.93)
  BOTTOM w0.076: U14.AW26 144.46,80.1 144.31,80.1 144.26,80.05 144.26,79.66 144.23,79.61 144.19,79.52 144.18,79.5 144.18,79.37 144.21,79.31 144.24,79.25 144.26,79.21 144.26,78.82 143.88,78.44 143.88,77.83 141.91,75.86 141.91,75.13 141.54,74.76 141.54,74.33 v2(141.13,73.93)
  BOTTOM w0.114: JDIM1.29 124.01,43.7 123.83,43.52 123.83,43.12 123.3,42.58 123.3,41.69 123.68,41.31 123.86,41.31 124.04,41.49 124.04,41.85 v2(123.96,41.92)
M_B_DQSP2: length 57.9
  IN3 w0.076: 145.94,77.38 145.94,77.38 145.94,78.15 142.6,81.49 142.6,82.19 142.78,82.37 142.78,83.43 142.96,83.6 143.1,83.6 v2(143.34,83.85)
  IN3 w0.102: 145.94,77.38 145.94,73.97 146.41,73.49 146.41,66.36 143.77,63.72 143.77,61.99 134.2,52.42 134.2,52.02 134.01,51.83 133.61,51.83 133.3,51.51 133.3,51.2 133.69,50.81 133.69,50.67 133.4,50.38 133.26,50.38 132.87,50.77 132.55,50.77 132.27,50.48 132.27,49.84 132.49,49.61 132.49,49.42 132.27,49.19 132.27,48.78 132.49,48.56 132.6,48.56 132.7,48.45 132.7,48.05 132.6,47.95 132.49,47.95 132.27,47.73 132.27,45.26 130.82,43.81 130.82,42.2 130.67,42.05 130.39,42.05 130.31,42.12 v2(130.31,42.68)
  BOTTOM w0.114: v2(143.34,83.85) 143.67,84.17 U14.AM28 ; v2(130.31,42.68) 130.31,42.25 130.16,42.1 129.98,42.1 129.73,42.35 129.73,42.61 129.24,43.09 129.24,43.52 129.41,43.69 JDIM1.47
M_B_DQSP3: length 60.4
  IN3 w0.076: v2(145.25,83.85) 145.49,83.6 145.63,83.6 145.81,83.43 145.81,82.94 146.31,82.43 146.31,81.7 147.1,80.91 149.44,80.91 150.35,80
  IN3 w0.102: 150.35,80 151.72,78.62 151.72,72.7 151.24,72.22 151.24,63.99 148.62,61.37 148.62,57.28 137.55,46.21 137.55,41.38 136.1,39.93 136.1,39.7 135.45,39.05 135.24,39.05 135.11,38.92 v2(135.11,38.67)
  BOTTOM w0.114: JDIM1.64 134.51,37.87 134.35,38.04 134.35,38.84 134.66,39.15 134.91,39.15 135.11,38.95 v2(135.11,38.67) ; v2(145.25,83.85) 145.57,84.17 U14.AM25
M_B_DQSP4: length 53.7
  IN1 w0.076: 142.67,72.25 142.71,72.29 142.71,72.5 143.01,72.81 143.54,72.81 144.24,73.51 144.24,74.52 144.5,74.78 144.78,74.78 v2(144.94,74.94)
  IN1 w0.102: v2(158.49,41) 158.49,41.33 158.34,41.48 158.09,41.48 157.7,41.86 157.7,45.07 157.87,45.23 157.87,45.75 157.7,45.91 157.7,49.42 146.72,60.4 146.72,61.14 142.67,65.19 142.67,72.25
  BOTTOM w0.076: v2(144.94,74.94) 146.06,76.06 146.06,78.25 146.79,78.99 146.79,79.18 146.75,79.28 146.74,79.28 146.72,79.33 146.72,79.54 146.79,79.69 146.79,79.83 146.75,79.93 146.72,79.98 146.72,80.19 146.78,80.33 146.78,80.34 146.86,80.41 147.18,80.73 U14.AV22
  BOTTOM w0.114: JDIM1.137 158.81,43.7 158.63,43.52 158.63,43.14 159.42,42.35 159.42,41.82 159.07,41.46 158.78,41.46 158.49,41.17 v2(158.49,41)
M_B_DQSP5: length 52.8
  IN1 w0.076: v2(148.16,74.61) 148.04,74.61 147.89,74.46 147.89,73.6 147.13,72.83 147.13,72.54 147.16,72.5
  IN1 w0.102: 147.16,72.5 147.16,67.03 163.42,50.77 163.42,46.3 163.81,45.91 163.81,45.4 163.42,45.01 163.42,44.7 163.85,44.27 163.85,40.27 164.05,40.07 164.05,39.55 v2(164.57,39.03)
  BOTTOM w0.076: U14.AW18 149.39,79.87 149.39,79.66 149.36,79.61 149.32,79.52 149.31,79.5 149.31,79.37 149.34,79.31 149.37,79.25 149.39,79.21 149.39,78.82 149.03,78.46 149.03,76.74 148.76,76.48 148.76,75.61 148.56,75.41 148.56,74.78 148.4,74.61 v2(148.16,74.61)
  BOTTOM w0.114: JDIM1.154 163.91,37.76 163.76,37.91 163.76,38.11 163.99,38.34 163.99,38.67 164.35,39.03 v2(164.57,39.03)
M_B_DQSP6: length 58.2
  IN1 w0.076: 150.73,75.68 150.73,77.66 149.17,79.22 148.58,79.22 146.45,81.35 146.45,82.12 146.85,82.51 147.15,82.51 147.6,82.96 147.6,83.45 v2(148,83.85)
  IN1 w0.102: v2(168.28,42.51) 168.28,42.1 168.44,41.95 168.64,41.95 168.77,42.08 168.77,42.82 168.44,43.15 168.44,45.31 167.56,46.19 167.56,51.96 150.87,68.64 150.87,72.56 150.73,72.69 150.73,75.68
  BOTTOM w0.114: v2(168.28,42.51) 168.28,42.18 168.08,41.97 167.9,41.97 167.78,42.1 167.78,42.79 167.98,42.99 168.41,42.99 168.84,43.42 168.84,43.57 169.01,43.74 JDIM1.171 ; U14.AM21 148.32,84.17 v2(148,83.85)
M_B_DQSP7: length 60.9
  IN1 w0.076: 154.64,78.06 154.5,78.19 154.42,78.19 152.31,80.3 151.72,80.3 150.64,81.38 150.64,83.31 150.31,83.64 150.11,83.64 v2(149.9,83.85)
  IN1 w0.102: v2(174.46,39.94) 174.25,39.94 174,40.19 174,40.64 174.39,41.03 174.39,41.34 174.96,41.92 174.96,43.6 174.27,44.29 174.27,44.62 174.66,45.01 174.66,53.13 157.52,70.27 157.52,70.42 157.74,70.64 157.74,70.98 157.31,71.41 156.97,71.41 156.74,71.19 156.6,71.19 156.09,71.7 156.09,76.6 154.64,78.06
  BOTTOM w0.114: JDIM1.188 174.11,37.75 173.95,37.91 173.95,39.43 v2(174.46,39.94) ; U14.AM18 150.23,84.17 v2(149.9,83.85)
M_B_ODT: length 3.7
  TOP w0.102: Q18.1 110.88,45.43 110.85,45.4 R168.2 R167.2 v1(108.86,44.7)
M_B_ODT0: length 53.6
  TOP w0.102: v1(111.84,44.11) 111.66,43.92 R168.1 110.85,43.6 v2(111.21,43.24)
  IN3 w0.114: v2(154.06,38.77) 153.11,38.77 151.72,37.37 138.79,37.37 138.13,37.37 137.45,36.69 119.68,36.69 119.02,37.34 113.45,37.34 111.21,39.58 v2(111.21,43.24)
  BOTTOM w0.102: v2(154.06,38.77) 153.48,38.77 152.51,37.81 JDIM1.116
M_B_ODT1: length 52.4
  TOP w0.102: R167.1 109.84,43.67 v2(110.73,42.79)
  IN3 w0.114: v2(110.73,42.79) 110.73,38.35 111.96,37.11 118.93,37.11 119.58,36.46 137.54,36.46 138.23,37.15 151.81,37.15 152.78,38.11 v2(154.06,38.11)
  BOTTOM w0.102: v2(154.06,38.11) 153.71,37.76 JDIM1.120
M_B_RAS#: length 70.4
  IN1 w0.076: v2(139.02,83.85) 139.42,83.45 139.42,81.65 139.26,81.5 139.26,79.65 138.77,79.16 138.77,78.32 138.13,77.68 138.13,74.97 137.68,74.51 137.68,74.15
  IN1 w0.14: 137.68,74.15 137.68,61.91 151.62,47.97 151.62,47.81 151.21,47.41 151.21,47.18 151.62,46.77 151.62,37.91 151.06,37.35 150.15,37.35 149.79,36.99 144.05,36.99 143.92,37.12 143.92,37.32 144.05,37.45 149.49,37.45 150.15,38.11 v2(150.66,38.11)
  BOTTOM w0.165: v2(139.02,83.85) 139.35,84.17 U14.AM35 ; JDIM1.110 150.71,38.06 v2(150.66,38.11)
M_B_WE#: length 69.6
  IN1 w0.076: v2(139,85.15) 139.58,84.57 139.58,83.52 139.58,83.52 139.58,81.66 140.18,81.06 140.18,79.98 138.97,78.78 138.97,78.24 138.31,77.58 138.31,74.84 138.08,74.61 138.08,74.15
  IN1 w0.14: 138.08,74.15 138.08,62.06 138.26,61.89 138.46,61.89 138.77,62.2 138.96,62.2 139.16,62 139.16,61.8 138.85,61.49 138.85,61.29 139.05,61.1 139.25,61.1 139.56,61.41 139.76,61.41 139.95,61.21 139.95,61.01 139.64,60.7 139.64,60.5 139.84,60.31 140.04,60.31 140.35,60.62 140.55,60.62 140.74,60.42 140.74,60.22 140.43,59.91 140.43,59.71 140.63,59.52 140.83,59.52 141.14,59.83 141.34,59.83 141.53,59.63 141.53,59.43 141.22,59.12 141.22,58.92 141.42,58.73 141.62,58.73 141.93,59.04 142.13,59.04 142.32,58.84 142.32,58.64 142.01,58.33 142.01,58.13 142.21,57.94 142.41,57.94 142.72,58.25 142.92,58.25 143.11,58.05 143.11,57.85 142.8,57.54 142.8,57.34 143,57.14 143.2,57.14 143.51,57.46 143.71,57.46 143.9,57.26 143.9,57.06 143.59,56.75 143.59,56.55 143.85,56.29 144.05,56.29 144.36,56.6 144.56,56.6 144.76,56.41 144.76,56.21 144.44,55.9 144.44,55.7 144.64,55.5 144.84,55.5 145.15,55.81 145.35,55.81 145.55,55.62 145.55,55.42 145.24,55.11 145.24,54.91 145.43,54.71 145.63,54.71 145.94,55.02 146.14,55.02 146.34,54.83 146.34,54.63 146.03,54.32 146.03,54.12 146.22,53.92 146.42,53.92 146.73,54.23 146.93,54.23 147.13,54.04 147.13,53.84 146.82,53.53 146.82,53.33 147.01,53.13 147.21,53.13 147.52,53.44 147.72,53.44 147.92,53.25 147.92,53.05 147.61,52.74 147.61,52.54 152.01,48.13 152.01,47.85 152.15,47.71 152.43,47.71 152.56,47.58 152.56,47.28 152.43,47.15 152.15,47.15 152.01,47.01 152.01,46.73 152.15,46.59 152.8,46.59 152.94,46.45 152.94,46.17 152.8,46.03 152.15,46.03 152.01,45.89 152.01,45.62 152.15,45.48 152.8,45.48 152.94,45.34 152.94,45.06 152.8,44.92 152.15,44.92 152.01,44.78 152.01,44.43 152.15,44.29 152.62,44.29 152.76,44.15 152.76,43.87 152.62,43.73 152.15,43.73 152.01,43.59 152.01,43.43 v2(152.13,43.32)
  BOTTOM w0.165: v2(139,85.15) 139.32,85.47 U14.AK35 ; JDIM1.113 151.61,43.84 v2(152.13,43.32)
MCP_RSVD_19: length 6.1
  BOTTOM w0.102: TP35.1 119.79,78.69 121.37,80.26
  BOTTOM w0.381: 121.37,80.26 U14.AV63
MCP_RSVD_20: length 4.8
  BOTTOM w0.102: U14.AU63 121.51,81.06 119.87,81.06 TP29.1
MCP_RSVD_21: length 16.1
  TOP w0.102: v2(119.44,100.32) 119.44,103.85 120.52,104.93 120.52,110.22 119.11,111.63 TP1.1
  BOTTOM w0.076: U14.C63 121.42,100.42 120.76,101.08 119.97,101.08 119.44,100.54 v2(119.44,100.32)
MCP_RSVD_22: length 15
  TOP w0.102: v2(120.07,100.32) 120.07,103.9 120.79,104.62 120.79,110.23 120.28,110.75 TP2.1
  BOTTOM w0.076: U14.C62 121.9,100.09 121.31,100.09 121.12,100.29 121.12,100.49 120.87,100.74 120.47,100.74 120.07,100.34 v2(120.07,100.32)
MCP_RSVD_24: length 1.4
  BOTTOM w0.076: TP17.1 129.32,101.8 U14.A51
MCP_RSVD_25: length 5.7
  BOTTOM w0.076: 129.57,102.65 129.57,101.4 U14.B51
  BOTTOM w0.102: TP3.1 129.88,104.18 129.88,102.96 129.57,102.65
MCP_RSVD_26: length 9.3
  TOP w0.102: v2(119.08,94.58) 118.09,95.57 115.86,95.57 TP4.1
  BOTTOM w0.076: v2(119.08,94.58) 119.16,94.58 119.6,95.02 122.64,95.02 122.68,94.98 123.17,94.98 U14.L60
MCP_RSVD_69: length 14.1
  TOP w0.102: v2(123.15,94.17) 121.78,92.8 116.31,92.8 116.26,92.85 114.71,92.85 114.59,92.98 113.85,92.98 113.54,92.67 111.51,92.67 TP45.1
  BOTTOM w0.076: U14.P60 123.47,93.83 123.12,94.17 v2(123.15,94.17)
MCP_RSVD_70: length 11.3
  TOP w0.102: TP47.1 113.34,93.18 113.57,93.41 114.59,93.41 114.89,93.1 116.3,93.1 116.4,93 120.67,93 121.86,94.18 v2(122.52,94.18)
  BOTTOM w0.076: v2(122.52,94.18) 122.81,93.88 U14.P61
MCP_RSVD_71: length 15.6
  TOP w0.102: TP40.1 125.87,107.81 125.87,102.23 125.6,101.97 125.07,101.97 124.34,101.23 124.34,98.56 123.93,98.16 123.93,96.23 124.54,95.63 v2(124.54,94.91)
  BOTTOM w0.102: U14.N59 124.23,94.6 124.54,94.9 v2(124.54,94.91)
MCP_RSVD_72: length 9.9
  TOP w0.102: TP43.1 114.56,96.73 115.5,96.73 115.76,96.48 116.31,96.48 116.84,95.95 118.35,95.95 v2(119.72,94.58)
  BOTTOM w0.076: v2(119.72,94.58) 119.99,94.85 122.56,94.85 U14.N61
MDI0+: length 11.9
  TOP w0.089: v2(293.66,46.39) 293.66,46.4 293.49,46.57 293.15,46.57 293.05,46.46 U6.1
  BOTTOM w0.089: v2(293.66,46.39) 293.91,46.65 294.21,46.65 294.56,46.29 ESD5.6 294.56,45.26 295.26,44.56 295.78,44.56 295.87,44.65 297.31,44.65 297.69,45.03 298.99,45.03 EC22.2 299.46,44.94 299.6,45.08 299.92,45.08 300.41,44.6 U19.1
MDI0-: length 11.9
  TOP w0.089: U6.2 292.55,46.87 292.66,46.76 292.92,46.76 293.03,46.86 293.53,46.86 v2(293.69,47.03)
  BOTTOM w0.089: U19.2 300.42,45.87 299.93,45.38 299.55,45.38 299.46,45.47 EC21.2 298.95,45.33 297.57,45.33 297.19,44.94 296.55,44.94 296.46,45.04 ESD5.4 296.46,46.28 296.32,46.42 294.85,46.42 294.33,46.94 293.78,46.94 v2(293.69,47.03)
MDI1+: length 16.7
  TOP w0.089: v2(294.83,49.06) 295.18,49.41 295.18,49.63 295,49.81 294.61,49.81 294.2,49.4 294.2,48.76 293.22,47.77 292.59,47.77 292.48,47.67 U6.4
  BOTTOM w0.089: U19.5 300.26,49.68 299.87,50.06 299.51,50.06 299.33,49.88 EC20.2 298.81,50.04 298.38,50.04 298.09,49.75 298.09,47.9 297.09,46.9 296.54,46.9 295.98,46.9 295.49,47.39 295.21,47.39 294.56,48.04 ESD5.1 294.56,48.79 v2(294.83,49.06)
MDI1-: length 16.6
  TOP w0.089: v2(296.25,49.03) 296.08,49.03 295.47,49.64 295.47,49.75 295.13,50.1 294.49,50.1 293.91,49.52 293.91,48.88 293.1,48.06 U6.5
  BOTTOM w0.089: U19.6 300.34,50.95 299.75,50.35 299.42,50.35 299.33,50.45 EC19.2 298.88,50.33 298.26,50.33 297.8,49.87 297.8,48.02 296.97,47.19 296.1,47.19 295.97,47.32 295.97,47.51 296.1,47.64 296.38,47.64 296.46,47.72 ESD5.3 296.46,48.82 v2(296.25,49.03)
MDI2+: length 19.1
  TOP w0.089: v2(293.48,50.66) 293.33,50.51 293.33,50.23 293.04,49.94 293.04,48.97 292.53,48.46 U6.6
  BOTTOM w0.089: v2(293.48,50.66) 293.26,50.87 293.26,51 292.86,51.41 292.86,52.66 293.38,53.17 294.27,53.17 294.37,53.07 294.37,52.96 294.28,52.87 294.03,52.87 293.93,52.77 ESD4.6 293.93,51.09 294.03,50.99 294.94,50.99 295.04,50.89 295.04,50.77 295.31,50.49 296.44,50.49 296.92,50.98 296.92,51.41 298.23,52.72 298.8,52.72 EC18.2 299.33,52.57 299.42,52.67 299.91,52.67 300.36,52.22 U19.7
MDI2-: length 19.1
  TOP w0.089: v2(292.84,50.66) 293.04,50.47 293.04,50.35 292.74,50.06 292.74,49.09 292.52,48.87 U6.7
  BOTTOM w0.089: v2(292.84,50.66) 292.97,50.79 292.97,50.88 292.57,51.28 292.57,52.78 293.26,53.47 294.39,53.47 294.66,53.19 294.66,53.01 294.72,52.95 295.64,52.95 295.83,52.76 ESD4.4 295.83,51.52 295.73,51.42 295.44,51.42 295.33,51.32 295.33,50.89 295.44,50.79 296.32,50.79 296.63,51.1 296.63,51.53 298.11,53.01 298.89,53.01 EC17.2 299.33,53.06 299.44,52.96 299.87,52.96 300.4,53.49 U19.8
MDI3+: length 23.9
  TOP w0.089: v2(294.14,55.51) 294.72,56.09 294.72,56.27 294.55,56.45 293.84,56.45 293.02,55.64 293.02,51.68 292.21,50.86 291.26,50.86 291.13,50.74 291.13,50.57 291.2,50.5 U6.9
  BOTTOM w0.089: v2(294.14,55.51) 294.04,55.51 293.93,55.4 ESD4.1 293.93,54.2 294.11,54.01 294.72,54.01 294.99,53.75 294.99,53.69 295.26,53.41 296.26,53.41 297.29,54.44 297.29,55.71 v1(297.77,56.2) 297.29,56.68 297.29,57.26 297.82,57.8 298.8,57.8 EC16.2 299.33,57.68 299.42,57.77 299.86,57.77 300.33,57.3 U19.11
MDI3-: length 23.8
  TOP w0.089: v2(295.66,55.49) 295.02,56.13 295.02,56.39 294.67,56.74 293.71,56.74 292.73,55.76 292.73,51.8 292.09,51.15 291.14,51.15 290.84,50.86 290.84,50.66 290.8,50.62 U6.10
  BOTTOM w0.089: U19.12 300.36,58.57 299.86,58.06 299.49,58.06 299.33,58.22 EC15.2 298.89,58.09 297.7,58.09 297,57.38 297,56.69 v1(296.5,56.2) 297,55.7 297,54.56 296.14,53.71 295.38,53.71 295.28,53.81 295.28,53.96 295.38,54.06 295.73,54.06 295.83,54.16 ESD4.3 295.83,55.3 295.66,55.46 v2(295.66,55.49)
ME_SUS_PWR_ACK: length 93.5
  TOP w0.102: v2(187.31,65.82) 187.31,63.91 187,63.61 187,60.64 188.05,59.6 189.21,59.6 189.72,60.11 193,60.11 197.57,55.54 197.57,46.83 200.37,44.03 222,44.03 v1(222.39,44.41) 223.48,45.5 230.77,45.5 232.09,44.18 236.67,44.18 v2(236.91,44.42) ; v2(182.81,69.94) 182.71,70.04 177.83,70.04 176.18,71.69 174.88,71.69 173.8,72.78 173.8,75.78 174.33,76.31 174.33,77.44 174.06,77.71 R103.1
  BOTTOM w0.102: v2(182.81,69.94) 182.89,70.01 183.37,70.01 185.43,67.96 185.43,67.7 v2(187.31,65.82) ; U23.68 236.45,43.09 236.91,43.55 v2(236.91,44.42)
ME_SUS_PWR_ACK_R: length 20.9
  TOP w0.102: R109.1 R103.2 R102.1 172.95,78.79 171.92,79.82 v2(171.81,79.82)
  BOTTOM w0.076: 161.63,80.53 160.61,80.53 160.39,80.75 159.8,80.75 159.77,80.78 159.37,80.78 159.2,80.95 159.2,81.14 158.95,81.38 158.71,81.38 158.48,81.16 158.48,80.89 158.17,80.57 U14.AV4
  BOTTOM w0.102: 161.63,80.53 161.73,80.43 162.06,80.43 165.36,77.13 168.99,77.13 170.76,78.89 170.89,78.89 v2(171.81,79.82)
MEM_VDD_CTL: length 6.9
  BOTTOM w0.102: TP31.1 177.47,82.49 181.46,82.49 182.43,83.45 182.93,83.45 183.47,84
  BOTTOM w0.381: U13.B2 183.47,84
MEM_VREF_CTL: length 10.4
  BOTTOM w0.102: TP32.1 178.82,81.86 179.36,81.32 179.83,81.32 180.34,81.82 185.19,81.82 185.66,82.29 185.66,82.93 185.5,83.08 185.5,84.14 185.95,84.58 U13.C5
MODPHY_EN: length 39.1
  TOP w0.102: PR14.1 169.65,113.83 170.47,113.02 170.9,113.02 171.64,112.28 v1(171.64,111.29) 171.64,110.86 171.36,110.58 v2(171.36,108.27)
  BOTTOM w0.076: 163.43,92.8 163.02,92.8 162.38,92.16 162.38,92.02 162.38,91.94 161.92,91.48 160.75,91.48 160.33,91.06 160.02,91.06 159.73,90.77 U14.Y2
  BOTTOM w0.102: 163.43,92.8 163.8,92.8 163.9,92.7 167.42,92.7 167.72,92.7 168.07,93.05 170.01,93.05 170.14,93.18 170.81,93.18 170.91,93.28 171.28,93.28 172.08,94.08 173.53,94.08 173.77,94.32 173.77,96.96 172.35,98.39 172.35,104 173.19,104.84 173.19,106.44 v2(171.36,108.27)
MX0: length 28.7
  TOP w0.102: v2(230.87,40.6) 231.28,41.01 231.83,41.01 232.37,40.47 234.17,40.47 235.49,39.15 235.49,32.57 232.9,29.98 v1(232.9,28.36) 232.9,27.88 232.65,27.62 C392.1 232.31,25.65 232.16,25.79 v2(232.16,26.53)
  BOTTOM w0.102: CN16.1 232.32,26.68 v2(232.16,26.53) ; v2(230.87,40.6) 231.67,41.4 231.67,44.07 231.49,44.24 U23.58
MX1: length 27.5
  TOP w0.102: v2(231.53,40.58) 231.83,40.27 234.02,40.27 235.29,39 235.29,32.66 232.7,30.07 232.7,28.89 231.73,27.93 v1(231.73,27.37) 231.73,25.75 C391.1 231.32,25.65 231.22,25.75 231.22,26.48 v2(231.28,26.53)
  BOTTOM w0.102: CN16.2 231.32,26.76 231.28,26.71 v2(231.28,26.53) ; U23.59 231.89,44.4 231.95,44.34 231.95,40.99 v2(231.53,40.58)
MX2: length 30.6
  TOP w0.102: v2(228.38,26.27) 228.58,26.07 C388.1 228.24,25.65 227.97,25.91 227.97,26.44 229.16,27.62 230.48,27.62 232.09,29.23 232.09,30.47 233.62,32 233.62,34.41 234.68,35.47 234.68,38.44 233.64,39.48 232.11,39.48 v2(231.45,38.82)
  BOTTOM w0.102: v2(228.38,26.27) 228.32,26.33 CN16.5 ; v2(231.45,38.82) 231.4,38.87 231.4,39.36 232.29,40.25 U23.60
MX3: length 30.2
  TOP w0.102: v2(232.09,38.82) 232.55,39.28 233.55,39.28 234.48,38.36 234.48,36.08 v1(233.97,35.57) 233.41,35.02 233.41,32.08 231.88,30.56 231.88,29.31 230.4,27.82 229.07,27.82 228.63,27.39 227.64,27.39 227.39,27.14 227.39,26.67 227.54,26.52 227.54,25.67 C387.1 227.77,25.85 227.77,26.81 v2(227.82,26.86)
  BOTTOM w0.102: U23.61 232.69,44.79 232.61,44.7 232.61,39.78 232.09,39.25 v2(232.09,38.82) ; v2(227.82,26.86) 227.54,26.86 227.32,27.08 CN16.6
MX4: length 29.1
  TOP w0.102: v2(226.88,26.89) 227.31,26.46 227.31,26.05 226.92,25.65 C386.1 226.54,25.65 226.42,25.77 226.42,27.04 226.69,27.3 227.05,27.3 227.77,28.03 v1(228.46,28.03) 229.07,28.03 229.73,28.69 229.73,29.44 230.9,30.62 231.66,30.62 233.21,32.17 233.21,35.55 234.27,36.61 234.27,37.96 v2(233.41,38.82)
  BOTTOM w0.102: CN16.7 226.32,27.14 226.57,26.89 v2(226.88,26.89) ; U23.62 233.09,44.79 232.9,44.59 232.9,40.26 233.41,39.75 v2(233.41,38.82)
MX5: length 30.9
  TOP w0.102: v2(232.75,38.82) 233.15,38.42 233.53,38.42 234.07,37.87 234.07,36.74 233.01,35.68 233.01,32.25 231.58,30.82 230.82,30.82 229.47,29.48 229.47,28.87 229.14,28.54 227.57,28.54 v1(227.19,28.15) 226.2,27.16 226.2,26.08 226.11,26 226.11,25.78 225.98,25.65 C385.1 225.53,26.17 v2(225.61,26.25)
  BOTTOM w0.102: U23.63 233.49,44.61 233.15,44.27 233.15,41.14 233.84,40.46 233.84,38.54 233.66,38.36 233.21,38.36 v2(232.75,38.82) ; v2(225.61,26.25) 225.15,26.71 225.15,27.06 225.32,27.23 CN16.8
MX6: length 34.8
  TOP w0.102: v2(223.22,26.58) 223.22,26.35 223.5,26.07 C383.1 223.19,25.65 222.79,26.04 222.79,28 v1(222.56,28.23) 222.08,28.71 222.08,34.17 223.66,35.75 223.66,36.38 224.01,36.74 230.57,36.74 231,37.16 231,37.81 231.2,38.01 232.49,38.01 v2(233,37.5)
  BOTTOM w0.102: U23.64 233.89,44.35 233.38,43.83 233.38,41.68 234.07,40.99 234.07,38.29 233.84,38.06 233.56,38.06 v2(233,37.5) ; v2(223.22,26.58) 223.32,26.68 CN16.10
MX7: length 36.5
  TOP w0.102: v2(222.39,26.53) 222.49,26.43 C382.1 222.08,25.65 221.88,25.85 v1(221.88,27.11) 221.88,35.17 221.42,35.62 221.42,36.36 222,36.94 230.49,36.94 230.79,37.25 230.79,37.93 231.1,38.24 232.9,38.24 v2(233.64,37.5)
  BOTTOM w0.102: v2(233.64,37.5) 233.99,37.5 234.3,37.81 234.3,41.46 233.6,42.17 233.6,43.53 234.35,44.29 U23.65 ; v2(222.39,26.53) 222.32,26.59 CN16.11
MY0: length 35.1
  TOP w0.102: v2(225,40.63) 225.41,41.03 229.78,41.03 230.89,39.91 233.97,39.91 235.09,38.8 235.09,34.99 234.78,34.68 v1(234.78,33.46) 234.78,32.44 232.49,30.15 232.49,29.04 230.61,27.16 C390.1 230.3,25.65 230.21,25.74 v2(230.21,26.5)
  BOTTOM w0.102: U23.36 222.69,43.97 225,41.67 v2(225,40.63) ; v2(230.21,26.5) 230.21,26.82 230.32,26.94 CN16.3
MY1: length 35.5
  TOP w0.102: v2(225.66,40.6) 229.42,40.6 v1(230.21,39.81) 230.31,39.71 233.82,39.71 234.88,38.64 234.88,35.39 233.84,34.34 233.84,31.94 232.29,30.39 232.29,29.15 230.56,27.42 229.47,27.42 228.86,26.81 228.86,26.06 229.27,25.65 C389.1 229.6,25.92 229.27,26.25 v2(229.27,26.5)
  BOTTOM w0.102: CN16.4 229.32,26.55 v2(229.27,26.5) ; U23.37 223.09,43.88 225.66,41.31 v2(225.66,40.6)
MY2: length 45.3
  TOP w0.102: v2(224.09,26.61) 224.52,26.17 C384.1 224.14,25.65 223.94,25.85 223.94,26.02 223.66,26.3 223.66,27.06 223.48,27.24 v1(223.48,27.3) 223.48,28.03 222.28,29.22 222.28,34.02 224.09,35.83 v2(224.09,35.98)
  IN1 w0.089: v2(224.09,26.61) 224.09,27.09 224.01,27.16 208.52,27.16 208.32,26.96 v2(208.32,26.73)
  BOTTOM w0.102: v2(208.32,26.73) CN16.25 ; U23.38 223.49,43.78 226.07,41.2 226.07,40.43 225.25,39.62 225.17,39.62 223.12,37.57 223.12,37.1 224.09,36.13 v2(224.09,35.98) ; CN16.9 224.32,27.14 224.09,26.91 v2(224.09,26.61)
MY3: length 27.6
  TOP w0.102: C381.1 221.47,25.69 ; 221.47,25.69 221.08,25.69 220.89,25.88 220.89,28.08 v1(221.27,28.46) 221.67,28.87 221.67,35.04 221.14,35.57 221.14,36.46 222.08,37.4 v2(223.53,37.4) ; 221.47,25.69 v2(221.47,26.53)
  BOTTOM w0.102: U23.39 223.89,43.66 226.27,41.29 226.27,40.34 223.53,37.6 v2(223.53,37.4) ; CN16.12 221.32,26.68 v2(221.47,26.53)
MY4: length 28.9
  TOP w0.102: C380.1 220.45,25.67 ; 220.45,25.67 220.08,25.67 219.95,25.8 v1(219.95,27.09) 219.95,27.82 221.47,29.35 221.47,34.92 220.94,35.45 220.94,36.55 222.2,37.81 223.76,37.81 v2(224.19,37.37) ; 220.45,25.67 v2(220.45,26.53)
  BOTTOM w0.102: v2(220.45,26.53) 220.32,26.66 CN16.13 ; v2(224.19,37.37) 224.19,37.97 226.47,40.25 226.47,41.37 224.29,43.55 U23.40
MY5: length 30.1
  TOP w0.102: v2(219.32,26.54) 219.44,26.42 C379.1 219.03,25.65 218.85,25.82 218.85,27.88 v1(219.41,28.43) 220.15,28.43 220.38,28.66 220.38,29.65 220.43,29.7 220.43,32.44 220.73,32.74 220.73,36.63 222.11,38.01 224.19,38.01 v2(224.82,37.37)
  BOTTOM w0.102: CN16.14 v2(219.32,26.54) ; v2(224.82,37.37) 224.82,38.32 226.68,40.17 226.68,41.45 224.69,43.44 U23.41
MY6: length 30.8
  TOP w0.102: v2(225.45,37.37) 224.61,38.21 222.03,38.21 220.53,36.72 220.53,32.83 220.23,32.52 220.23,30.26 218.02,28.05 v1(218.02,27.67) 218.02,27.06 217.81,26.86 217.81,25.89 218.06,25.65 C378.1 218.42,26.43 v2(218.32,26.53)
  BOTTOM w0.102: U23.42 225.09,43.33 226.88,41.54 226.88,40.09 225.45,38.65 v2(225.45,37.37) ; CN16.15 v2(218.32,26.53)
MY7: length 32.2
  TOP w0.102: v2(226.07,37.37) 225.03,38.42 221.94,38.42 220.33,36.8 220.33,32.91 220.02,32.61 220.02,30.35 217.94,28.27 217.5,28.27 216.85,27.62 v1(216.85,27.16) 216.85,25.74 216.94,25.65 C377.1 217.41,26.44 v2(217.32,26.53)
  BOTTOM w0.102: CN16.16 v2(217.32,26.53) ; v2(226.07,37.37) 226.07,38.99 227.08,40 227.08,41.62 225.49,43.21 U23.43
MY8: length 33.5
  TOP w0.102: v2(216.32,26.53) 216.39,26.46 C376.1 216,25.65 215.83,25.81 215.83,27.34 v1(217.58,29.09) 218.48,29.09 219.82,30.43 219.82,32.69 220.12,33 220.12,36.89 221.86,38.62 225.46,38.62 v2(226.7,37.37)
  BOTTOM w0.102: CN16.17 v2(216.32,26.53) ; v2(226.7,37.37) 226.7,39.33 227.29,39.92 227.29,41.71 225.89,43.1 U23.44
MY9: length 35.3
  TOP w0.102: v2(215.32,26.53) 215.37,26.47 C375.1 215.11,25.65 214.79,25.97 214.79,27.04 v1(216.21,28.46) 217.6,29.84 218.94,29.84 219.62,30.52 219.62,32.78 219.92,33.08 219.92,36.97 221.77,38.82 225.92,38.82 v2(227.36,37.37)
  BOTTOM w0.102: v2(227.36,37.37) 227.06,37.68 227.06,39.4 227.49,39.83 227.49,41.89 226.29,43.09 226.29,43.11 226.13,43.28 226.13,44.67 226.29,44.83 U23.45 ; CN16.18 v2(215.32,26.53)
MY10: length 37.1
  TOP w0.102: v2(228,37.37) 226.35,39.03 221.69,39.03 219.72,37.05 219.72,33.16 219.41,32.86 219.41,30.66 218.8,30.05 217.11,30.05 v1(214.82,27.75) 213.85,26.78 213.85,25.77 213.97,25.65 C374.1 214.36,26.4 214.32,26.44 v2(214.32,26.53)
  BOTTOM w0.102: v2(228,37.37) 227.26,38.11 227.26,39.32 227.69,39.75 227.69,41.98 226.69,42.98 226.69,43 226.33,43.36 226.33,44.58 226.69,44.94 U23.46 ; CN16.19 v2(214.32,26.53)
MY11: length 35.5
  TOP w0.102: v2(228.23,38.8) 227.8,39.23 221.61,39.23 219.52,37.14 219.52,33.25 219.21,32.94 219.21,30.81 218.65,30.25 216.61,30.25 214.33,27.98 214.08,27.98 v1(213.34,27.24) 212.83,26.73 212.83,25.77 212.95,25.65 C373.1 v2(213.34,26.53)
  BOTTOM w0.102: CN16.20 213.32,26.55 v2(213.34,26.53) ; v2(228.23,38.8) 228.23,39.2 228.82,39.8 228.82,44.88 228.69,45.01 U23.51
MY12: length 37.5
  TOP w0.102: v2(212.33,26.53) C372.1 211.95,25.65 211.82,25.78 211.82,27.29 v1(212.1,27.57) 212.71,28.18 214.08,28.18 216.35,30.45 218.57,30.45 219.01,30.89 219.01,33.03 219.31,33.33 219.31,37.22 221.52,39.43 228.2,39.43 v2(228.86,38.77)
  BOTTOM w0.102: U23.52 229.09,39.61 228.86,39.38 v2(228.86,38.77) ; CN16.21 212.32,26.54 v2(212.33,26.53)
MY13: length 40.8
  TOP w0.102: v2(229.42,38.11) 229.42,39.05 228.84,39.64 227.98,39.64 221.44,39.64 219.11,37.31 219.11,33.42 218.8,33.11 218.8,30.98 218.48,30.66 216.27,30.66 214.02,28.41 211.82,28.41 210.8,27.39 v1(210.8,27.01) 210.8,25.78 210.93,25.65 C371.1 v2(211.31,26.53)
  BOTTOM w0.102: v2(229.42,38.11) 229.42,39.15 229.33,39.24 229.33,44.96 229.49,45.12 U23.53 ; v2(211.31,26.53) 211.32,26.54 CN16.22
MY14: length 43.4
  TOP w0.102: v2(229.89,37.58) 229.89,38.87 228.92,39.84 228.07,39.84 228.07,39.84 221.35,39.84 218.91,37.39 218.91,33.5 218.6,33.2 218.6,31.06 218.4,30.86 216.19,30.86 214.01,28.69 211.26,28.69 v1(210.9,28.33) 209.79,27.21 209.79,25.89 210.03,25.65 C370.1 v2(210.29,26.53)
  BOTTOM w0.102: v2(210.29,26.53) 210.32,26.55 CN16.23 ; v2(229.89,37.58) 229.89,39.11 229.61,39.4 229.61,44.88 229.89,45.16 U23.54
MY15: length 41.8
  TOP w0.102: v2(209.32,26.53) 209.32,25.69 C369.1 208.94,25.65 208.85,25.74 208.85,27.15 v1(209.19,27.48) 210.6,28.89 213.93,28.89 216.1,31.06 217.09,31.06 218.37,32.35 218.37,33.33 218.7,33.66 218.7,37.48 221.27,40.04 229.01,40.04 230.17,38.87 v2(230.36,38.87)
  BOTTOM w0.102: v2(230.36,38.87) 230.36,39.74 229.84,40.26 229.84,44.63 230.29,45.08 U23.55 ; CN16.24 v2(209.32,26.53)
N12E_SCL: length 6
  TOP w0.102: R97.1 187.05,80.83 v1(187.75,81.53) v2(188.27,82.05)
  BOTTOM w0.114: U13.C9 188.86,84.38 188.86,83.84 188.66,83.64 188.66,82.91 188.8,82.78 188.8,82.28 188.54,82.02 188.33,82.02 188.3,82.05 v2(188.27,82.05)
N12E_SDA: length 7.1
  TOP w0.102: R96.1 185.91,80.76 v1(186.3,81.15) 187.4,82.24 187.4,82.88 188.45,83.93 188.45,84.72 v2(187.97,85.2)
  BOTTOM w0.102: U13.C8 188.04,85.2 v2(187.97,85.2)
NB_MUTE#: length 76.6
  TOP w0.102: v2(282.55,35.18) 283.61,36.25 283.61,36.9 284.06,37.35 288.07,37.35 v1(288.35,37.63) 289.7,38.98 291.6,38.98 293.18,40.55 295.73,40.55 R444.1 296.18,40.09 297.42,40.09 297.82,39.69 299.46,39.69 299.84,39.31 303.31,39.31 304.06,38.56 U10.47
  IN3 w0.114: v2(282.55,35.18) 282.46,35.09 281.24,35.09 280.84,35.48 279.18,35.48 278.35,36.31 277.19,36.31 276.49,37.01 270.02,37.01 268.05,38.98 263.76,38.98 263.25,39.48 260.61,39.48 259.37,38.24 256.75,38.24 256.28,38.71 242.21,38.71 239.3,35.8 237.22,35.8 v2(236.79,36.23)
  BOTTOM w0.102: U23.84 236.49,36.69 236.79,36.38 v2(236.79,36.23)
Net_379: length 0.3
  BOTTOM w0.381: 184.3,83.2 184.3,83.16 184.11,82.97
Net_472: length 0.2
  BOTTOM w0.381: 183.5,103 183.25,103
Net_1553: length 0.4
  BOTTOM w0.381: 182.7,103 182.35,103
Net_1557: length 0.4
  BOTTOM w0.102: 183.5,103.8 183.49,103.8
  BOTTOM w0.381: 183.49,103.8 183.24,104.05
Net_1579: length 0.3
  BOTTOM w0.381: 182.7,84.8 182.43,84.8
Net_1580: length 0.1
  BOTTOM w0.381: 183.45,84.9 183.45,84.85 183.5,84.8
Net_1581: length 0.2
  BOTTOM w0.381: 184.3,104.6 184.05,104.6
Net_1582: length 0.2
  BOTTOM w0.381: 184.3,103 184.53,103
Net_1583: length 0.2
  BOTTOM w0.381: 184.3,103.8 184.51,103.8
Net_1624: length 0.2
  BOTTOM w0.381: 184.3,84.8 184.54,84.8
Net_1625: length 0.3
  BOTTOM w0.381: 184.3,84 184.3,83.73
Net_1702: length 0.4
  BOTTOM w0.33: 201.7,104.6 201.7,104.98
Net_1704: length 0.3
  BOTTOM w0.33: 201.7,103.8 201.46,103.56
Net_1707: length 0.3
  BOTTOM w0.381: 202.5,104.6 202.5,104.61 202.7,104.81
Net_1740: length 0.4
  BOTTOM w0.381: 122.49,80.17 122.24,80.42 122.16,80.42
Net_1940: length 0.4
  BOTTOM w0.254: 160.54,100.01 160.4,99.88 160.14,99.88
NFC_IRQ_R: length 11.2
  BOTTOM w0.076: 161.63,83.79 161.31,83.47 160.37,83.47 160.26,83.57 160.02,83.57 159.85,83.4 159.85,83.22 159.61,82.99 159.1,82.99 U14.AN3
  BOTTOM w0.102: 161.63,83.79 161.95,84.11 162.37,84.11 163.06,84.8 164.09,84.8 164.19,84.9 165.23,84.9 165.41,85.08 166.63,85.08 167.14,85.58 167.14,86.26 166.74,86.65 R345.1
NOA_RCOMP: length 3.8
  BOTTOM w0.178: U14.V63 121.01,91.56 120.76,91.81 119.74,91.81 v1(119.4,91.46) 119.11,91.18 R325.2
NOA_STBN_0: length 7.1
  BOTTOM w0.076: TP28.1 116.2,89.38 118.82,89.38 118.83,89.39 118.88,89.39 118.93,89.44 119.62,89.44 119.87,89.19 120.96,89.19 121.38,89.6 121.7,89.6 122.1,90.01 122.11,90.01 U14.AA62
NOA_STBN_1: length 5
  BOTTOM w0.076: TP23.1 117.39,92.6 117.97,92.6 118.09,92.72 120.94,92.72 121.35,92.31 U14.U63
NOA_STBP_0: length 9.6
  BOTTOM w0.076: U14.AA61 122.54,90.1 122.29,90.35 122.04,90.35 121.87,90.18 121.87,90.01 121.64,89.77 121.31,89.77 120.89,89.36 120.14,89.36 119.74,89.75 118.96,89.75 118.75,89.55 115.68,89.55
  BOTTOM w0.102: 115.68,89.55 115.32,89.55 115.1,89.32 114.64,89.32 TP27.1
NOA_STBP_1: length 4.3
  BOTTOM w0.076: TP21.1 118.47,92.44 120.97,92.44 121.39,92.02 121.64,92.02 121.93,92.31 U14.U62
NV_PLLVDD: length 7.9
  TOP w0.508: v2(185.5,91.02) 184.92,91.02 v1(184.54,90.64) 183.85,89.95 181.57,89.95 181.02,89.4 C137.2 180.36,89.4 180.27,89.5 C139.2 178.76,89.5 L10.1
NV_PWG: length 7.4
  TOP w0.102: v2(189.7,85.99) 189.7,85.89 190.15,85.43 190.15,84.87 189.95,84.67 v1(189.95,84.24) 189.95,83.43 188.98,82.46 188.98,80.36 R99.1
  BOTTOM w0.102: U13.D10 190.08,85.61 v2(189.7,85.99)
PANEL_HPD_R: length 6
  TOP w0.102: U25.11 249.93,29.61 v1(249.72,29.4) 249.52,29.2 R518.1 248.64,29.2 248.25,29.59 247.24,29.59 246.73,30.1 R517.1
PBAT_PRES#: length 343.8
  TOP w0.254: PQ5.5 23.39,89.47 24.72,88.14 v2(24.72,81.29) 23.56,80.12 v1(22.82,80.12) 22.68,80.12 PR28.1
  IN2 w0.114: v2(24.72,81.29) 24.72,79.97 24.97,79.72 24.97,69.21 32.52,61.66 32.52,59.5 40.04,51.98 45.58,51.98 50.76,46.8 50.76,38.61 50.44,38.3 50.44,37.03 51.67,35.8 51.67,33.77 v2(51.16,33.26)
  IN3 w0.114: v2(31.22,12.31) 30.74,12.31 29.52,13.52 29.52,14.06 32.16,16.7 32.29,16.7 35.14,19.54 52.13,19.54 54.24,21.65 v2(54.24,23.1) 55.96,23.1 57.59,24.73 65.26,24.73 67.04,22.95 76.18,22.95 76.56,23.33 85.23,23.33 86.06,24.17 88.5,24.17 90.24,25.91 91,25.91 91.7,26.61 104.68,26.61 107.12,29.04 110.98,29.04 114.46,32.52 119.44,32.52 119.91,32.99 145.79,32.99 146.72,32.06 147.37,31.41 154.78,31.41 157.39,34.02 179.34,34.02 184.13,29.23 186.05,29.23 187.46,27.82 187.46,27.57 188.29,26.74 189.35,26.74 191.92,24.17 201.2,24.17 202.55,22.82 202.86,22.82 202.86,22.82 203.05,22.82 203.05,22.82 203.13,22.82 204.35,21.6 207.47,21.6 208.64,20.43 210.42,20.43 210.67,20.18 227.21,20.18 228.58,21.55 230.01,21.55 230.64,20.92 232.72,20.92 232.93,21.12 235.77,21.12 238.84,24.19 238.84,26.2 238.49,26.55 v2(238.49,27.09)
  BOTTOM w0.102: v2(31.22,12.31) 31.28,12.25 31.66,12.25 32.12,11.79 PR205.2 ; v2(238.49,27.09) 239,26.58 239.53,26.58 239.81,26.86 239.81,30.55 240.95,31.69 240.95,32.8 241.51,33.36 242.45,33.36 243.72,34.63 243.72,35.8 243.1,36.42 PC171.2 242.78,36.84 243.37,37.43 243.37,38.09 242.96,38.49 242.45,38.49 242.1,38.85 R465.2 ; v2(51.16,33.26) 52.43,33.26 54.24,31.46 v2(54.24,23.1)
PCH_EDM: length 12.8
  BOTTOM w0.076: 161.63,79.67 161.55,79.74 160.69,79.74 160.64,79.79 160.35,80.08 160.24,80.08 160.24,80.09 159.93,80.09 159.77,80.25 159.66,80.25
  BOTTOM w0.102: v1(170.11,77.1) 169.21,76.19 R387.2 168.42,76.92 165.21,76.92 163.03,79.11 162.19,79.11 161.63,79.67
  BOTTOM w0.381: 159.66,80.25 U14.AV2
PCH_INTVRMEN: length 10.6
  BOTTOM w0.076: 156.6,76.82 156.57,76.85 156.24,76.85 155.68,77.41 155.68,78.73 155.73,78.77 155.73,80.16 U14.AV7
  BOTTOM w0.102: v1(158.76,72.58) 158.76,73.01 158.24,73.53 R407.2 157.55,73.53 157.44,73.64 157.44,74.36 157.59,74.51 157.59,75.18 157.84,75.43 R392.1 157.73,75.69 156.6,76.82
PCH_JTAG_TDO: length 12.4
  TOP w0.102: R67.2 112.54,87.77 v1(112.78,87.77) 115.76,87.77 116.28,88.28 117.3,88.28 117.81,87.77 121.15,87.77 121.57,88.19 v2(122.52,88.19)
  BOTTOM w0.102: U14.AE61 122.81,87.89 v2(122.52,88.19)
PCH_JTAGX: length 9.1
  BOTTOM w0.102: v1(113.8,86.3) 115.62,86.3 115.82,86.49 R347.2 116.21,86.85 116.67,86.4 117.93,86.4 118.05,86.52 R346.1 119.62,86.86 120.58,87.81 U14.AE63
PCH_MELOCK: length 122.8
  TOP w0.102: v1(153.42,69.43) 153.55,69.3 v2(154.49,69.3)
  IN3 w0.114: v2(154.49,69.3) 154.49,69.07 160.36,63.21 160.36,52.49 168.79,44.06 171.97,44.06 172.19,43.83 173.52,43.83 176.23,41.11 178.57,41.11 180.09,39.58 181.34,39.58 182.33,40.58 182.84,40.58 189.74,33.67 194.94,33.67 196.54,32.07 197.08,31.53 199.2,31.53 199.53,31.2 199.67,31.06 199.93,30.8 200.01,30.72 209,30.72 209.8,29.92 210.04,29.92 210.59,29.92 211.41,29.09 211.43,29.09 217.89,29.09 218.67,29.09 219.67,30.1 226.71,30.1 227.03,30.42 229.14,30.42 229.62,30.9 229.77,30.9 234.29,30.9 v2(235.01,30.19)
  BOTTOM w0.076: 154.21,73.82 154.21,74.07 154.67,74.52 R395.1
  BOTTOM w0.102: v2(154.49,69.3) 154.63,69.44 154.63,71.92 154.21,72.34 154.21,73.82 ; U23.85 234.5,36.29 232.11,33.9 232.11,32.48 232.35,32.24 233.81,32.24 234.78,31.28 234.78,30.42 v2(235.01,30.19)
PCH_OPIRCOMP: length 4.4
  BOTTOM w0.076: U14.AW15 151.52,79.52 150.9,78.91 150.9,78.85 150.85,78.79 150.85,78.43
  BOTTOM w0.305: 150.85,78.43 150.85,75.8 R397.1
PCH_SATA_LED#: length 82.2
  TOP w0.102: v2(161.65,92.24) 161.86,92.44 162.7,92.44 163.53,93.28 164.83,93.28 165.84,94.29 R51.1 ; LED3.1 175.62,126.07 C1.2 174.26,125.24 173.87,124.85 172.68,124.85 v1(172.5,125.02) 172.19,125.34 162.34,125.34 160.71,123.71 157.49,123.71 152.89,119.11 152.89,114.91 151.37,113.38 151.37,112.58 151.72,112.23 152.9,112.23 153.56,111.57 162.48,111.57 162.66,111.75 v2(162.66,112.38)
  IN2 w0.114: v2(162.66,112.38) 162.66,112.85 162.53,112.98 160.81,112.98 158.75,110.93 158.75,104.8 160.69,102.86 160.69,101.73 160.69,101.73 160.69,101.38 160.69,101.37 160.69,100.82 163.37,98.14 163.37,93.81 162.39,92.82 162.24,92.82 v2(161.65,92.24)
  BOTTOM w0.076: v2(161.65,92.24) 161.22,92.67 160.88,92.67 160.43,92.23 160.43,92.15 160.26,91.98 159.1,91.98 U14.U3
PCH_SLP_WLAN#: length 11.9
  TOP w0.102: v2(157.84,85.15) 158.5,84.49 159.38,84.49 160.08,83.79 160.08,83.75 160.51,83.32 160.74,83.32 161.65,82.41 161.65,78.95 162.11,78.49 162.11,77.66 TP51.1
  BOTTOM w0.076: U14.AM5 157.24,84.5 157.84,85.1 v2(157.84,85.15)
PCH_SMB_ALERT#: length 18.6
  IN3 w0.114: v2(161.3,84.03) 160.74,84.59 160.49,84.59 160.23,84.85 160.23,85.43 160.71,85.91 161.76,85.91 162.39,86.55 163.1,86.55 164.5,85.15 167.49,85.15 v2(167.55,85.1)
  BOTTOM w0.076: v2(161.3,84.03) 160.9,83.63 160.44,83.63 160.33,83.74 159.95,83.74 U14.AN2
  BOTTOM w0.102: R333.2 170.03,89.27 169.71,88.94 RP19.3 169.14,88.36 167.73,86.96 167.73,85.28 v2(167.55,85.1)
PCH_SPI_CLK: length 105.7
  IN1 w0.089: v2(162.8,90.54) 162.8,89.52 164.8,87.51 164.8,86.09 166.55,84.34 168.68,84.34 170.47,82.56 170.47,78.47 168.74,76.74 168.74,76.19 168.64,76.08 167.98,76.08 167.88,75.98 167.88,75.82 167.98,75.72 168.61,75.72 168.72,75.62 168.72,75.46 168.61,75.36 167.22,75.36 167.11,75.26 167.11,75.11 167.22,75.01 168.68,75.01 168.74,74.94 168.74,74.72 168.68,74.65 167.09,74.65 166.99,74.55 166.99,74.4 167.09,74.3 168.68,74.3 168.74,74.23 168.74,74.03 168.64,73.93 166.57,73.93 166.48,73.84 166.48,73.69 166.58,73.58 168.54,73.58 168.64,73.48 168.64,73.33 168.54,73.23 166.33,73.23 166.23,73.13 166.23,72.98 166.33,72.87 168.54,72.87 168.64,72.77 168.64,72.62 168.54,72.52 166.58,72.52 166.48,72.42 166.48,72.29 167.72,71.05 167.72,69.86 183.75,53.84 183.75,50.2 184.76,49.2 184.76,45.7 185.2,45.25 185.2,44.06 189.36,39.9 190.34,39.9 192.39,37.86 192.39,37.15 192.74,36.79 v2(192.92,36.79)
  BOTTOM w0.076: v2(162.8,90.54) 163.05,90.79 163.43,90.79 ; 163.43,90.53 163.03,90.13 161.81,90.13 161.17,89.5 160.33,89.5 160.26,89.56 159.65,89.56 159.52,89.7 159.16,89.7 158.84,90.02 U14.AA3
  BOTTOM w0.102: R457.2 190.51,40.89 190.63,41.01 R456.1 ; R457.2 189.97,41.59 v1(189.6,41.97) ; R457.2 189.75,40.89 189.57,40.71 189.57,38.03 190.81,36.79 v2(192.92,36.79) ; 163.43,90.79 163.68,90.79 EC13.1 163.67,90.53 163.43,90.53
PCH_SPI_CS0#: length 106.6
  TOP w0.102: v2(208.31,38.98) 207.45,39.84 206.71,39.84 206.46,39.59 205.47,39.59 205.33,39.72 R179.1 205.29,39.99 202.73,37.43 v2(202.73,32.98)
  IN1 w0.089: v2(202.73,32.98) 202.3,33.41 201.09,33.41 200.21,32.52 197.32,32.52 195,34.84 195,37.02 193.75,38.28 193.14,38.28 190.3,41.11 189.87,41.11 188.45,42.53 188.07,42.53 187.43,43.17 187.43,43.55 187.05,43.93 186.3,43.93 185.89,44.34 185.89,45.54 185.44,45.99 185.44,49.56 184.44,50.57 184.44,54.12 171.78,66.78 171.78,69.75 170.18,71.35 170.18,73.18 169.43,73.93 169.43,76.46 171.15,78.19 171.15,82.84 168.73,85.26 168.12,85.26 164.19,89.18 164.19,91.02 163.48,91.73 161.02,91.73 159.88,90.59 157.69,90.59 157.16,91.12 v2(157.16,91.11)
  BOTTOM w0.102: U14.Y7 156.71,91.14 157.14,91.14 157.16,91.12 v2(157.16,91.11) ; R452.1 207.66,39.44 207.85,39.44 v2(208.31,38.98)
PCH_SPI_CS1#: length 99
  TOP w0.102: R176.1 204.55,41.13 v1(203.97,40.55) 202.07,38.64 v2(202.07,32.98)
  IN1 w0.089: v2(162.16,90.54) 162.16,89.6 164.37,87.4 164.37,85.81 166.18,84 168.54,84 170.12,82.41 170.12,78.81 165.84,74.54 165.84,72.38 167.36,70.86 167.36,69.75 183.37,53.73 183.37,50.1 184.41,49.06 184.41,45.55 184.82,45.15 184.82,43.95 189.73,39.04 190.72,39.04 192.06,37.7 192.06,36.36 192.24,36.18 193.18,36.18 197.24,32.12 201.66,32.12 202.07,32.52 v2(202.07,32.98)
  BOTTOM w0.076: U14.Y4 158.33,90.73 158.63,90.44 158.88,90.44 159,90.31 160.33,90.31 160.99,90.97 161.78,90.97 162.16,90.59 v2(162.16,90.54)
PCH_SPI_SI: length 103.5
  IN1 w0.089: v2(161.5,90.56) 162.11,91.17 162.79,91.17 163.3,90.66 163.3,89.5 165.15,87.66 165.15,86.23 166.69,84.68 168.83,84.68 170.81,82.7 170.81,78.33 169.08,76.6 169.08,73.47 169.17,73.39 169.48,73.39 169.58,73.28 169.58,73.13 169.48,73.03 169.17,73.03 169.08,72.94 169.08,72.76 169.17,72.67 169.71,72.67 169.81,72.57 169.81,71.79 169.71,71.69 169.53,71.69 169.43,71.79 169.43,72.15 169.32,72.25 169.17,72.25 169.07,72.15 169.07,71.79 168.97,71.69 168.72,71.69 168.61,71.79 168.61,72.07 168.51,72.17 167.57,72.17 167.47,72.07 167.47,71.89 167.57,71.79 168.13,71.79 168.23,71.69 168.23,71.33 168.33,71.23 169.68,71.23 169.78,71.13 169.78,70.95 169.68,70.85 168.38,70.85 168.28,70.75 168.28,70.57 168.38,70.47 170.19,70.47 170.29,70.37 170.29,70.19 170.19,70.09 168.49,70.09 168.38,69.99 168.38,69.81 168.49,69.71 170.83,69.71 170.95,69.59 170.95,69.42 170.83,69.3 169.15,69.3 169.05,69.2 169.05,69.03 169.15,68.92 171.35,68.92 171.47,68.8 171.47,68.63 171.35,68.52 169.93,68.52 169.83,68.41 169.83,68.26 169.93,68.16 171.2,68.16 171.33,68.03 171.33,66.74 184.09,53.98 184.09,50.42 185.1,49.42 185.1,45.85 185.54,45.4 185.54,44.2 188.27,41.47 188.4,41.47 188.59,41.66 188.71,41.66 188.84,41.53 188.84,41.41 188.65,41.22 188.65,41.09 188.76,40.98 189.06,40.98 189.17,40.88 189.17,40.6 189.27,40.5 189.42,40.5 189.52,40.6 189.52,40.68 189.61,40.77 189.79,40.77 189.88,40.68 189.88,40.35 189.98,40.25 190.58,40.25 192.9,37.93 193.35,37.93 v2(194.32,36.97)
  BOTTOM w0.076: v2(161.5,90.56) 161.5,90.11 161.13,89.73 160.02,89.73 159.73,90.02 U14.AA2
  BOTTOM w0.102: v2(194.32,36.97) 194.8,37.45 194.8,37.58 193.48,38.9 192.9,38.9 192.39,39.41 191.85,39.41 191.42,38.98 R463.2 R460.1
PCH_SPI_SO: length 101.8
  TOP w0.102: v2(203.35,32.98) 203.35,36.75 v1(203.87,37.27) 205.32,38.72 R186.2 205.84,39.23 206.54,39.23 206.79,39.48 207.15,39.48 v2(207.65,38.98)
  IN1 w0.089: v2(158.53,89.66) 161.62,89.66 164.02,87.25 164.02,83.69 163.39,83.06 163.39,78.58 163.85,78.12 163.85,77.9 164.32,77.43 164.55,77.43 164.77,77.2 164.77,76.69 164.9,76.57 166.68,76.57 166.78,76.47 166.78,76.31 166.68,76.21 164.87,76.21 164.77,76.11 164.77,75.86 164.87,75.75 165.9,75.75 166,75.65 166,75.47 165.9,75.37 165.49,75.37 165.39,75.27 165.39,72.34 167.01,70.71 167.01,69.61 182.43,54.19 182.43,50.39 183.98,48.84 183.98,45.45 184.41,45.02 184.41,43.72 189.32,38.81 189.32,38.07 191.87,35.52 193.35,35.52 197.16,31.72 203.06,31.72 203.35,32.01 v2(203.35,32.98)
  BOTTOM w0.076: v2(158.53,89.66) 158.19,89.99 U14.AA4
  BOTTOM w0.102: v2(207.65,38.98) 206.38,40.25 R458.1
PCH_THRMTRIP#: length 12.3
  TOP w0.102: R12.1 v1(122.03,109.46) 122.03,109.08 122.35,108.76 122.35,104.09 121.45,103.19 v2(121.45,101.84)
  BOTTOM w0.076: v2(121.45,101.84) 121.94,101.34 122.3,101.34 122.49,101.15 122.49,100.94 122.83,100.61 122.83,100.4 123.29,99.94 U14.D60
PCI_PME_N: length 11.9
  TOP w0.102: TP48.1 168.64,88.53 165.95,88.53 165.8,88.38 162.9,88.38 162.16,89.11 160.34,89.11 159.81,88.58 159.19,88.58 159.16,88.56 158.97,88.56 158.57,88.15 v2(158.49,88.15)
  BOTTOM w0.076: U14.AD4 158.19,88.45 v2(158.49,88.15)
PCIE_CLK_REQ0#: length 12.3
  IN3 w0.114: v2(167.9,97.6) 167.43,97.13 166.06,97.13 v2(162.34,93.4)
  BOTTOM w0.076: v2(162.34,93.4) 161.94,93 160.74,93 160.47,92.73 159.95,92.73 U14.U2
  BOTTOM w0.102: v2(167.9,97.6) 168.37,98.06 169.25,98.06 RN1.1
PCIE_CLK_REQ1#: length 177.1
  TOP w0.102: R230.2 55.86,31.92 v2(55.86,31.91) 54.95,31.91 v1(54.92,31.94)
  IN3 w0.076: 153.01,91.4 155.17,91.4 155.29,91.51 155.9,91.51 155.93,91.47 156.58,91.47 156.62,91.51 157.4,91.51 157.78,91.13 v2(157.82,91.13)
  IN3 w0.114: v2(157.82,91.13) 158.27,91.58 162.97,91.58 163.12,91.72 163.43,91.72 163.67,91.97 163.67,93.51 165.83,95.67 168.99,95.67 169.22,95.9 169.22,97.83 168.99,98.06 167.74,98.06 v2(167.28,97.6) ; v2(55.86,31.91) 55.79,31.91 55.34,31.47 55.34,30.2 57.56,27.98 63.41,27.98 64.11,27.28 74.82,27.28 75.29,26.81 75.83,26.81 76.59,27.57 78.82,27.57 79.48,28.23 82.38,28.23 85.63,31.48 90.03,31.48 90.87,32.33 101.65,32.33 106.64,37.31 106.64,44.18 109.03,46.57 109.03,48.72 110.59,50.29 110.59,51.36 114.15,54.92 114.15,60.35 113.97,60.54 113.97,67.26 114.92,68.21 114.92,72.63 120.13,77.84 120.13,83.46 122.69,86.02 122.69,86.17 123.4,86.88 124.55,86.88 124.88,87.21 124.88,87.61 125.62,88.35 126.21,88.35 126.39,88.53 130.18,88.53 134,92.35 142.1,92.35 142.14,92.39 146.31,92.39 147.56,91.15 149.2,91.15 149.29,91.05 150.45,91.05 150.79,91.39 153,91.39 153.01,91.4
  BOTTOM w0.076: U14.Y5 157.51,90.83 157.8,91.13 v2(157.82,91.13)
  BOTTOM w0.102: RN1.3 167.83,98.56 167.3,98.02 167.3,97.61 v2(167.28,97.6)
PCIE_CLK_REQ2#: length 211.9
  IN3 w0.114: v2(246.16,37.88) 246.08,37.96 243.01,37.96 240.06,35.01 235.72,35.01 235.29,35.44 229.22,35.44 228.89,35.77 227.08,35.77 226.59,35.28 225.79,35.28 225.27,34.76 219.18,34.76 218.8,34.38 214.92,34.38 214.33,34.96 210.78,34.96 209.74,36 201.04,36 200.71,36.33 198.37,36.33 194.65,40.05 192.65,40.05 192.65,40.05 192.6,40.05 190.98,41.67 190.74,41.67 186.81,45.6 186.81,45.9 185.19,47.52 183.15,47.52 179.83,47.52 178.69,48.65 178.12,48.65 177.48,49.29 176.14,49.29 171.13,54.31 171.13,57.19 172.71,58.77 172.71,61.93 171.78,62.86 171.78,69.2 171.83,69.24 174.46,71.87 177.21,71.87 177.95,72.62 177.95,77.25 177.69,77.52 177.69,79.49 177.34,79.84 177.34,83 177.22,83.12 177.22,87.49 177.87,88.13 177.87,89.72 177.38,90.2 177.38,94.22 176.49,95.11 176.49,95.76 175.57,96.68 172.09,96.68 169.22,99.55 v2(168.41,99.55) 168.41,99.13 169.62,97.92 169.62,94.58 168.64,93.6 167.97,93.6 167.68,93.31 166.43,92.07 166.43,90.11 164.4,88.07 160.61,88.07 v2(160.59,88.05) ; v2(260.82,43.01) 261.58,43.78 262.21,43.78 263.58,42.4 265.41,42.4 266.71,41.11 270.7,41.11 272.14,39.66 276.41,39.66 277.63,38.44 280.35,38.44 281.16,37.63 v2(281.16,36.94)
  BOTTOM w0.076: v2(160.59,88.05) 160.14,88.49 U14.AD1
  BOTTOM w0.102: v2(168.41,99.55) 168.41,99.35 168.7,99.06 RN1.5 ; v2(281.16,36.94) 281.24,36.94 281.41,37.12 R446.1 282.3,37.57 283.32,38.59 284.45,38.59 Q42.1 ; v2(246.16,37.88) 246.16,37.93 248.15,39.92 248.15,42.32 249.68,43.85 258,43.85 v1(258.25,44.11) 258.81,43.55 258.81,43.24 259.14,42.91 260.71,42.91 v2(260.82,43.01)
